.so bibtex.header

@Book{aiial,
  author       = "Richard Hofstadter",
  title        = "Anti-intellectualism in American Life",
  publisher    = "Knopf",
  year         = 1963,
  address      = nyny,
  keywords     = "american history",
  location     = "E 169.1.H74"
}

@Book{cwth,
  author       = "Tony Hillerman",
  title        = "Coyote Waits",
  publisher    = "Harper \& Row",
  year         = 1990,
  address      = nyny,
  keywords     = "murrdaar, academic glory",
  location     = "PS 3558.I45 C69"
}

@Book{jmtsg,
  author       = "Simon Garfield",
  title        = "Just My Type",
  publisher    = "Gotham Books",
  year         = 2010,
  address      = nyny,
  keywords     = "fonts, font design, artistry",
  location     = "Z 250.G228"
}

@Book{tfmth,
  author       = "Tony Hillerman",
  title        = "The Fallen Man",
  publisher    = "HarperCollins",
  year         = 1996,
  address      = nyny,
  keywords     = "fraud, timing",
  location     = "PS 3558.I45 F65"
}

@Book{nakrd,
  author       = "Robert Dallek",
  title        = "Nixon and Kissinger",
  publisher    = "HarperCollins",
  year         = 2007,
  address      = nyny,
  keywords     = "nixon, kissinger, foreign policy, us politics",
  location     = "E 856 D35"
}

@Book{mbbed,
  author       = "Emanual Derman",
  title        = "Models. Behaving. Badly.",
  publisher    = "Free Press",
  year         = 2011,
  address      = nyny,
  keywords     = "financial models, physics models, theories",
  location     = "QA 401 D37"
}

@Book{mamtcs,
  author       = "Thomas~C. Schelling",
  title        = "Micromotives and Macrobehavior",
  publisher    = "W. W. Norton \& Co.",
  year         = 1978,
  address      = nyny,
  keywords     = "aggregate results",
  location     = "H 61 S355"
}

@Book{smsja,
  author       = "Julia Angwin",
  title        = "Stealing MySpace",
  publisher    = "Random House",
  year         = 2009,
  address      = nyny,
  keywords     = "myspace, the internet bubble, media companies, the web",
  location     = "HD 9696.8 U64 M973"
}

@Book{twprlh,
  author       = "Robert~L. Heilbroner",
  title        = "The Worldly Philosophers",
  publisher    = "Simon and Schuster",
  year         = 1980,
  address      = nyny,
  edition      = "fifth",
  keywords     = "economics, history",
  location     = "HB 76 H4"
}

@Book{tgrmp,
  title        = "Tiffany Glass",
  publisher    = "The Montreal Museum of Fine Arts",
  year         = 2009,		  
  editor       = "Rosalind~M. Pepall",
  keywords     = "tiffany, glass arts, stained class",
  location     = "NK 5198 TS A4"
}

@Book{padmd,
  author       = "Mary Douglas",
  title        = "Purity and Danger",
  publisher    = "Ark Paperbacks",
  year         = 1984,
  address      = "London, England",
  keywords     = "anthropology, tabu, pollution, ritual",
  location     = "GN 494 D6"
}

@Book{tgswre,
  author       = "Richard Ellis",
  title        = "The Great Sperm Whale",
  publisher    = "University Press of Kansas",
  year         = 2011,
  address      = "Lawrence, Kansas",
  keywords     = "whales, ocean biology, moby dick, whale hunting",
  location     = "QL 737 C435 E437"
}

@Book{spipll,
  author       = "Ian Foster",
  title        = "Systems Programming in Parallel Logic Languages",
  publisher    = ph,
  year         = 1990,
  address      = nyny,
  keywords     = "operating systems, parallel logic languages, flat parlog,
    functional programming",
  location     = "QA 76.66.F67"
}

@Book{sccittoc,
  author       = "Geoffrey Colin Harcourt",
  title        = "Some Cambridge Controversies in the Theory of Capital",
  publisher    = cup,
  year         = 1972,
  address      = loen,
  keywords     = "captial, it fails us now",
  location     = "HB 501 H349"
}

@Book{nwgab,
  author       = "William Gibson",
  title        = "Neuromancer",
  publisher    = "Ace Books",
  year         = 1984,
  address      = nyny,
  keywords     = "the future, ai",
  location     = "PS 3557.I2664 N48"
}

@Book{cacam,
  author       = "Charles~A. Murray",
  title        = "Coming Apart",
  publisher    = "Crown Forum",
  year         = 2012,
  address      = nyny,
  keywords     = "class, morality, social capital, the poors",
  location     = "E 184 A1 M895"
}

@Book{pitbdws,
  author       = "David Warren Sabean",
  title        = "Power in the Blood",
  publisher    = cup,
  year         = 1984,
  address      = cen,
  keywords     = "social life, germany, customs, religion",
  location     = "BR 857.W8 S22"
}

@Book{tpnqagsll,
  author       = "Richard~J. Lipton",
  title        = "The {P} = {NP} Question and G{\" o}del's Lost Letter",
  publisher    = "Springer",
  year         = 2010,
  address      = nyny,
  keywords     = "complexity theory, mathematics",
  location     = "QA 9.65 L57"
}

@Book{msttwjm,
  author       = "Wilbert~J. McKeachie and Marilla Svinicki",
  title        = "McKeachie's Teaching Tips",
  publisher    = "Houghton Mifflin",
  year         = 2006,
  address      = boma,
  edition      = "Twelfth",
  keywords     = "course prep, class meeting, learning, discussion, lecturing,
    assessing, testing, cheating, grading, motivation, cultural diversity,
    problem students, writing, active learning, problem-based learning,
    teaching technology, large classes, laboratory instruction, experiential
    learning, distance education, thinking, ethics, growth",
  location     = "LB 1738 M35"
}

@Book{tfeth,
  author       = "Tony Hillerman",
  title        = "The First Eagle",
  publisher    = "HarperCollins",
  year         = 1998,
  address      = nyny,
  keywords     = "murrrdaaar, bubonic plague",
  location     = "PS 3558.I45 F49"
}

@Book{etraf,
  author       = "Loren Fox",
  title        = "Enron: The Rise and Fall",
  publisher    = "John Wiley",
  year         = 2003,
  address      = honj,
  keywords     = "enron, the free market, financial fraud, regulation, the way
    we live now",
  location     = "HD 9502 U54 E5739"
}

@Book{relwm,
  author       = "Elmore Leonard",
  title        = "Raylan",
  publisher    = "William Morrow",
  year         = 2012,
  address      = nyny,
  keywords     = "kidneys, coal, poker",
  location     = "PS 3562.E55 R39"
}

@Book{hbth,
  author       = "Tony Hillerman",
  title        = "Hunting Badger",
  publisher    = "HarperCollins",
  year         = 1999,
  address      = nyny,
  keywords     = "casino robberies, murrdaar, deceptions",
  location     = "PS 3558.I45 H86"
}

@Book{tgrrmt,
  author       = "Richard~M. Titmuss",
  title        = "The Gift Relationship",
  publisher    = "Pantheon Books",
  year         = 1971,
  address      = nyny,
  keywords     = "blood banks, blood donors",
  location     = "RM 171 T57"
}

@Book{ejndd,
  author       = "Jim Newton",
  title        = "Eisenhower",
  publisher    = "Doubleday",
  year         = 2011,
  address      = nyny,
  keywords     = "eisenhower, american presidency, politics, 1950s",
  location     = "E 836.N49"
}

@Book{mrb,
  author       = "Ronald Bishop",
  title        = "More",
  publisher    = "Baylor University Press",
  year         = 2011,
  address      = "Waco, Texas",
  keywords     = "scale, modern life, media-driven existence, kids these days",
  location     = "HM 621.B57"
}

@Book{scth,
  author       = "Tony Hillerman",
  title        = "Sacred Clowns",
  publisher    = "HarperCollins",
  year         = 1993,
  address      = nyny,
  keywords     = "murrdaar, friends, wheels within wheels",
  location     = "PS 3558.I45 S23"
}

@Book{wsayo,
  author       = "Thomas Geoghegan",
  title        = "Which Side Are You On?",
  publisher    = "Farrar, Straus \& Giroux",
  year         = 1991,
  address      = nyny,
  keywords     = "labor, labor history, labor law",
  location     = "HD 2872.5 G46"
}

@Book{stph,
  author       = "Terry Pratchett",
  title        = "Snuff",
  publisher    = "Harper",
  year         = 2011,
  address      = nyny,
  keywords     = "the law in its majesty",
  location     = "PR 6066.R34 S65"
}

@Book{mtus,
  author       = "Marianne Brandon",
  title        = "Monogamy: The Untold Story",
  publisher    = "Praeger",
  year         = 2010,
  address      = "Santa Barbara, California",
  keywords     = "monogamy, romance, love, marriage",
  location     = "BF 692 B73"
}

@Book{tssth,
  author       = "Tony Hillerman",
  title        = "The Shape Shifter",
  publisher    = "HarperCollins",
  year         = 2006,
  address      = nyny,
  keywords     = "murrdaar, identity",
  location     = "PS 3558.I45 S45"
}

@Book{pgtj,
  author       = "Christophe Porteneuve",
  title        = "Pragmatic Guide to JavaScript",
  publisher    = "The Pragmatic Bookshelf",
  year         = 2010,
  address      = ranc,
  keywords     = "javascript, dom, events, timers, ui, server-side programming,
    mashups, debugging, frameworks",
  location     = "QA 76.73.J39 P668"
}

@Book{folrms,
  author       = "Raymond~M. Smullyan",
  title        = "First-Order Logic",
  publisher    = "Dover",
  year         = 1995,
  address      = nyny,
  keywords     = "first-order logic, analytic tableaux, compactness theorem,
    quantification theory, axiom systems, magic sets, gentzen systems,
    elimination theorems, prenix tableaux",
  location     = "QA 9.S57"
}

@Book{acdtr,
  author       = "Daniel~T. Rodgers",
  title        = "Atlantic Crossings",
  publisher    = "Belknap Press",
  year         = 1998,
  address      = cma,
  keywords     = "social policies, progressive politics, economics,
    collectivism, city planning, conservatism, social insurance, cooperative
    farming, agricultural policy, modernism, the new deal",
  location     = "HN 57 R556"
}

@Book{achwb,
  author       = "H. W. Brands",
  title        = "American Colossus",
  publisher    = "Anchor Books",
  year         = 2010,
  address      = nyny,
  keywords     = "capitalism, the gilded age, speculation, railroad companies,
    cattle, corruption, industrial development, labor, banking ",
  location     = "HC 105.B813"
}

@Book{tcsjn,
  author       = "Jeremy Narby",
  title        = "The Cosmic Serpent",
  publisher    = "Jeremy P. Tarcher",
  year         = 1998,
  address      = nyny,
  keywords     = "shamanism, psychoreacitve drugs",
  location     = "F3429.3 D79 N3713"
}

@Book{tspth,
  author       = "Tony Hillerman",
  title        = "The Sinister Pig",
  publisher    = "HarperCollins",
  year         = 2003,
  address      = nyny,
  keywords     = "murrdaar, drugs",
  location     = "PS 3558.I45 S46"
}

@Book{csbatts,
  author       = "Wiliam Kennedy",
  title        = "Chang{\' o}'s Beads and Two-Tone Shoes",
  publisher    = "Viking",
  year         = 2011,
  address      = nyny,
  keywords     = "revolution, reactionaries",
  location     = "PS 3561.E428 C47"
}

@Book{btsrp,
  author       = "Rick Perlstein",
  title        = "Before the Storm",
  publisher    = "Hill and Wang",
  year         = 2001,
  address      = nyny,
  keywords     = "american politics, 1964 presidential elections, barry
    goldwater, lyndon johnson", 
  location     = "E 748 G64 P37"
}

@Book{sslb,
  author       = "Leslie Brunetta and Catherine~L. Craig",
  title        = "Spider Silk",
  publisher    = "Yale University Press",
  year         = 2010,
  address      = nhco,
  keywords     = "spiders, evolution, webs, fossil",
  location     = "QL 459.B78"
}

@Book{tpoprac,
  author       = "Robert~A. Caro",
  title        = "The Passage of Power",
  publisher    = "Knopf",
  year         = 2012,
  address      = nyny,
  keywords     = "politics, vice presidency, assassination",
  location     = "E 846.C37"
}

@Book{tgth1989,
  author       = "Tony Hillerman",
  title        = "Talking God",
  publisher    = "Harper \& Row",
  year         = 1989,
  address      = nyny,
  keywords     = "murrdaar, patsies",
  location     = "PS 3558.I45 T35"
}

@Book{tcocs,
  author       = "Joseph~A. Tainter",
  title        = "The Collapse of Complex Socities",
  publisher      = cup,
  year         = 1988,
  month        = cen,
  keywords     = "complex societies, collapse theory, archaeology, economics,
    roman empire, mayan civilization, chacoan civilization",
  location     = "CB 311 T245"
}

@Book{wlmtw,
  author       = "Tim Wise",
  title        = "White Like Me",
  publisher    = "Soft Skull Press",
  year         = 2008,
  address      = nyny,
  keywords     = "racism, white privilege, american culture, race relations",
  location     = "E 185.615.W565"
}

@Book{ipornec,
  author       = "Noble~E. {Cunningham, Jr.}",
  title        = "In Pursuit of Reason",
  publisher    = "Louisiana State University Press",
  year         = 1987,
  address      = "Baton Rouge, Louisiana",
  keywords     = "jefferson, american revolution, republican politics",
  location     = "E 332 C95"
}

@Book{1q84,
  author       = "Haruki Murakami",
  title        = "1Q84",
  publisher    = "Knopf",
  year         = 2011,
  address      = nyny,
  keywords     = "twin worlds",
  location     = "PL 856.U673 A61213"
}

@Book{gtmb,
  author       = "Mark Blyth",
  title        = "Great Transformations",
  publisher    = cup,
  year         = 2002,
  address      = cen,
  keywords     = "polanyi, institutional change, liberalism, united states,
    sweden", 
  location     = "JC 574.2 U6 B59"
}

@Book{twwth,
  author       = "Tony Hillerman",
  title        = "The Wailing Wind",
  publisher    = "HarperCollins",
  year         = 2002,
  address      = nyny,
  keywords     = "murrdaar, the ol' double-cross",
  location     = "PS 3558.I45 W34"
}

@Book{tote,
  author       = "Christopher Hayes",
  title        = "Twilight of the Elites",
  publisher    = "Crown",
  year         = 2012,
  address      = nyny,
  keywords     = "meritocracy, moral hazards, classes, economic development",
  location     = "HN 90.E4 H39"
}

@Book{butb,
  author       = "Hilary Mantel",
  title        = "Bring Up the Bodies",
  publisher    = "Henry Holt",
  year         = 2012,
  address      = nyny,
  keywords     = "henry viii, thomas cromwell, anne boleyn",
  location     = "PR 6063.A438 B75"
}

@Book{twalg,
  author       = "Ed McBain",
  title        = "There Was a Little Girl",
  publisher    = "Warner Books",
  year         = 1994,
  address      = nyny,
  keywords     = "murrdaar",
  location     = "PS 3515.U585 T44"
}

@Book{popcdb,
  author       = "Christopher {de Bellaigue}",
  title        = "Patriot of Persia",
  publisher    = "Harpers",
  year         = 2012,
  address      = nyny,
  keywords     = "iran, international politics, government, iran",
  location     = "DS 318.6.D42"
}

@Book{tmpje,
  author       = "Jeffrey Eguenides",
  title        = "The Marriage Plot",
  publisher    = "Farrar, Straus and Giroux",
  year         = 2011,
  address      = nyny,
  keywords     = "young life",
  location     = "PS 3555.U4 M37"
}

@Book{ofat,
  author       = "Anthony Trollope",
  title        = "Orley Farm",
  publisher    = oup,
  year         = 1985,
  address      = oxuk,
  keywords     = "scandal, best-laid plans",
  location     = "PR 5684.O7"
}

@Book{tdmc,
  author       = "S.~S. {Van Dine}",
  title        = "The Dragon Murder Case",
  publisher    = "Bantam",
  year         = 1949,
  address      = nyny,
  keywords     = "family planning, murrdaar",
  location     = "PS 3545 R846 D7"
}

@Book{dtf50y,
  author       = "David Graeber",
  title        = "Debt, The First 5,000 Years",
  publisher    = "Melville House",
  year         = 2011,
  address      = "Brooklyn, New York",
  keywords     = "debt, finance, economics, history",
  location     = "HG 3701.G73"
}

@Book{ptpcqhv,
  author       = "Quang Hieu Vu and Mihai Lupu and Beng Chin Ooi",
  title        = "Peer-to-Peer Computing",
  publisher    = "Springer",
  year         = 2010,
  address      = "Heidelberg, Germany",
  keywords     = "networking, routing, applications, load balancing,
    replication, security, trust, programming tools",
  location     = "TK 5105.525.V83"
}

@Book{pms2003,
  author       = "Marjane Satrapi",
  title        = "Persepolis",
  publisher    = "Pantheon",
  year         = 2003,
  address      = nyny,
  keywords     = "iranian revolution, coming of age",
  location     = "PN 6747 S245 P4713"
}

@Book{aidlpakm,
  author       = "David~L. Poole and Alan~K. Mackworth",
  title        = "Artificial Intelligence",
  publisher    = cup,
  year         = 2010,
  address      = cen,
  keywords     = "agents, states, searching, constraints, propositions,
    inference, uncertain reasoning, learning, planning, multiagent systems,
    ontologies, knowledge-based systems",
  location     = "Q 342.P66"
}

@Book{tgmc,
  author       = "S.~S. {Van Dine}",
  title        = "The Garden Murder Case",
  publisher    = "Scribner's",
  year         = 1935,
  address      = nyny,
  keywords     = "murrdaar, the hidden snake",
  location     = "PZ3.W9384 Ga"
}

@Book{rdtml,
  author       = "Thomas~M. Lessl",
  title        = "Rhetorical Darwinism",
  publisher    = "Baylor University Press",
  year         = 2010,
  address      = "Waco, Texas",
  keywords     = "evolutionary theory, evolutionism, religious history, science
    philosophy, science and religion",
  location     = "Q 172.5 P82 L47"
}

@Book{efsrk,
  author       = "Robert Kuttner",
  title        = "Everything for Sail",
  publisher    = "Knopf",
  year         = 1997,
  address      = nyny,
  keywords     = "economic policy, industrial policy, capitalism, markets,
    labor, medicine, money markets, regulation, competition, politics",
  location     = "HC 106.82 K87"
}

@Book{bbgb,
  author       = "Bruno~G. Breitmeyer",
  title        = "Blindspots",
  publisher    = oup,
  year         = 2010,
  address      = nyny,
  keywords     = "vision, blindness",
  location     = "BF 241 B728"
}

@Book{twonyb,
  author       = "Yochai Benkler",
  title        = "The Wealth of Networks",
  publisher    = "Yale University Press",
  year         = 2006,
  address      = nhco,
  keywords     = "networks, information economy, social production, mass media,
    culture, public policy",
  location     = "HM 851 B457"
}

@Book{spf,
  author       = "Paula Fredriksen",
  title        = "Sin",
  publisher    = pup,
  year         = 2012,
  address      = prnj,
  keywords     = "sin, christian theology, jesus, paul, valintinus, marcion,
    justin, origen, augustine", 
  location     = "BT 715 F74"
}

@Book{tsmcssvd,
  author       = "S.~S. Van~Dine",
  title        = "The Scarab Murder Case",
  publisher    = "Grosset \& Dunlap",
  year         = 1930,
  address      = nyny,
  keywords     = "murrdaar, two-way misdirection",
  location     = "PZ 3.W9384"
}

@Article{mapapmlic,
  author       = "Michael~C. Ring",
  title        = "{MAPM}, {A} Portable Arbitrary Precision Math Library in {C}",
  journal    = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 11,
  monty        = nov,
  pages        = "28--38",
  keywords     = "fast multiplication, newton-raphson",
  location     = "http://drdobbs.com/showArticle.jhtml?articleID=184401456&queryText=fft"
}

@Article{ioafo,
  author       = "Matt Austern",
  title        = "{I}\slash {O} and Function Objects",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 9,
  pages        = "61--64",
  month        = sep,
  keywords     = "character classification, traits, function objects",
  location     = "http://drdobbs.com/184403800"
}

@Article{v,
  author       = "Herb Sutter",
  title        = "Virtuality",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 9,
  pages        = "53--58",
  month        = sep,
  keywords     = "visibility, virtuality, oo design",
  location     = "http://www.gotw.ca/_themes/gotw/glabkgnd.jpg"
}

@Article{etstlwac,
  author       = "Eli Tilevich",
  title        = "Extending the Standard Template Library with Association Classes",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 9,
  pages        = "40--52",
  month        = sep,
  keywords     = "associations, oo design",
  location     = "http://drdobbs.com/184401437"
}

@Article{acdsfw,
  author       = "Mark Nelson",
  title        = "A " # cpp # " Debug Stream for {Win32}",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 9,
  pages        = "30--38",
  month        = sep,
  keywords     = "tracing, debugging",
  location     = "http://drdobbs.com/184401432"
}

@Article{aafeiw,
  author       = "Bob Lorenzen",
  title        = "An Algorithm for Efficient Image Warping",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 9,
  pages        = "20--28",
  month        = sep,
  keywords     = "image processing, bressenham line drawing",
  location     = "http://drdobbs.com/architecture-and-design/184401431"
		  
}

@Article{iruotm,
  author       = "Shehrzad Qureshi",
  title        = "Image Rotation Using {OpenGL} Texture Maps",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 9,
  pages        = "10--17",
  month        = sep,
  keywords     = "texture maps, image processing, rendering loop, bilinear
    interpolation",
  location     = "http://drdobbs.com/cpp/184401434"
}

@Article{sitsl,
  author       = "Matt Austern",
  title        = "Searching in the Standard Library",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 11,
  pages        = "80--86",
  month        = nov,
  keywords     = "linear search, binary search, sequential containers",
  location     = "http://drdobbs.com/architecture-and-design/184401450"
}

@Article{tsfomf,
  author       = "Herb Sutter",
  title        = "The String Formatters of Manor Farm",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 11,
  pages        = "60--72",
  month        = nov,
  keywords     = "sprintf, snprintf, string streams, lexical casts",
  location     = "http://drdobbs.com/cpp/184401458"
}

@Article{aaem,
  author       = "Kalin Nakov",
  title        = "An Asynchronous Execution Macro",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 11,
  pages        = "54--58",
  month        = nov,
  keywords     = "macro proprocessor",
  location     = "http://drdobbs.com/184401454"
}

@Article{atftnnp,
  author       = "Larry Andrews",
  title        = "{A} Template for the Nearest Neighbor Problem",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 11,
  pages        = "40--49",
  month        = nov,
  keywords     = "neartrees, triangle inequality",
  location     = "http://drdobbs.com/184401449"
}

@Article{owsa,
  author       = "Mark Bucci",
  title        = "Optimization with Simulated Annealing",
  journal      = ccppuj,
  year         = 2001,
  volume       = 19,
  number       = 11,
  pages        = "10--27",
  month        = nov,
  keywords     = "simulated annealing, optimization",
  location     = "http://drdobbs.com/184401451"
}

@Article{vdomes,
  author       = "Mikko Kerttula and Timo Tokkonen",
  title        = "Virtual Design of Multiengineering Electronics Systems",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "71--79",
  month        = nov,
  keywords     = "product development, process support, virtual reality",
  abstract     = "The authors describe a virtual reality prototyping (VRP) and
    virtual product design approach that uses a modeling strategy to design,
    test, and evaluate concepts and products in advance-before creating any
    physical design models.  Their design decisions reflect solutions and
    practices derived from systems engineering and software engineering
    research in projects that focused primarily on developing small-sized
    consumer electronics and telecommunications products such as cellular
    phones, other personal terminals, set-top boxes, and wrist computers.Close
    competition has forced companies to focus on tailoring technological
    products to meet customer preferences in user interface design, usability,
    and appearance.  Often, implementing new features has assumed less
    importance than creating an optimal product variation for different
    customer segments in international markets.  Modern computer-based systems
    result from a multidomain development process, and organizing this work
    requires developers to communicate, cooperate, and coordinate effectively
    with nonengineering teams.  Early linking of product development to other
    company operations supports this activity.Geographically dispersed
    development teams must communicate and coordinate effectively.  Distance
    and time differences provide the first obstacles, but businesses also must
    overcome linguistic and cultural challenges.  Extending the use of
    interactive, functional, and photorealistic 3D product models into other
    company domains can facilitate effective business practices that cover the
    entire value chain, from simulated product idea to Web-based customer
    support of the final product.  This wider adoption of the VRP technology
    and process offers ample scope for further research.",
  location     = "http://dx.doi.org/10.1109/2.963447"
}

@Article{rssfmcsld,
  author       = "Perry Alexander and Cindy Kong",
  title        = "Rosetta: Semantic Support for Model-Centered Systems-Level Design",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "64--70",
  month        = nov,
  keywords     = "modeling, domain interaction, components",
  abstract     = "With the advent of system-on-chip (SoC) technology, the
    design of small electrical systems has become a systems engineering task.
    Such tasks require working at high levels of abstraction to build systems
    by either integrating information from various design domains or modeling
    different aspects of the same component.  Designers of traditional
    computer-based systems usually rely on component- based techniques that
    parallel the physical architecture.  The model-based approach encompasses
    the component-- centered approach, treating structural decomposition as a
    single model in the overall hierarchy.  Model-centered semantics and
    languages let designers concentrate on the data, computation, or
    communication models that describe complex computer-based SoC requirements.
    Appropriate design semantics specify each system aspect, and the designer
    assembles those aspects into models to define complete systems and
    components.  The developers of Rosetta, a heterogeneous systems-level
    modeling language that supports predictive design analysis, have identified
    mechanisms for defining and composing models that specify multiple domains
    of interest from many perspectives.  Rosetta requirements and domains
    define test cases and generate abstract vectors for each test scenario.
    Several analysis tools are under development for transforming Rosetta into
    existing analysis environments, and the authors are also developing native
    analysis tools for symbolic verification and simulation environments.  The
    authors use Rosetta to provide computation models for customized digital
    and mixed-signal system-specification environments.  Other domains to
    support optical and microelectrical mechanical systems specifications are
    under consideration.", 
  location     = "http://dx.doi.org/10.1109/2.963446"
}

@Article{eesawa,
  author       = "Andy~D. Pimentel and Louis~O. Hertzberger and Paul Lieverse
    and Pieter {van der Wolf} and  Ed~F. Deprettere",
  title        = "Exploring Embedded-Systems Architectures with {A}rtemis",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "57--63",
  month        = nov,
  keywords     = "modeling, simulation",
  abstract     = "Because embedded systems mostly target mass production and 
    often run on batteries, they should be cheap to realize and power
    efficient.  In addition, they require a high degree of programmability to
    provide real-time performance for multiple applications and standards.
    However, performance requirements as well as cost and power-consumption
    constraints demand that substantial parts of these systems be implemented
    in dedicated hardware blocks.  As a result, their heterogeneous system
    architecture consists of components ranging from fully programmable
    processor cores to fully dedicated hardware components for time critical
    application tasks.  Increasingly, these designs yield heterogeneous
    embedded multiprocessor systems that reside together on a single chip.  The
    heterogeneity of these highly programmable systems and the varying demands
    of their target applications greatly complicate system design.  The
    increasing complexity of embedded- system architectures makes predicting
    performance behavior more difficult.  Therefore, having the appropriate
    tools to explore different choices at an early design stage is increasingly
    important.  The Artemis modeling and simulation environment aims to
    efficiently explore the design space of heterogeneous embedded-systems
    architectures at multiple abstraction levels and for a wide range of
    applications targeting these architectures.  The authors describe their
    application of this methodology in two studies that showed promising
    results, providing useful feedback on a wide range of design decisions
    involving the architectures for the two applications.",
  location     = "http://dx.doi.org/10.1109/2.963445"
}

@Article{faadd,
  author       = "Tommi Mikkonen and Peeter Pruuden",
  title        = "Flexibility as a Design Driver",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "52--56",
  month        = nov,
  keywords     = "design, hardware requirements",
  abstract     = "Ambiguous requirements and those that emerge late in the 
    design cycle often complicate development and throw off established
    schedules.  The authors describe how reformulating information missing at
    the design stage into a flexibility requirement can turn the absent data
    into a design driver.  Designers constantly run into issues that have yet
    to be understood through specification, system design, or standardization.
    Changes in evolving technologies and businesses often result in unstable
    system requirements.  Reliable hardware or mechanical details might not be
    available until very late in the development process.  Yet engineers must
    initiate software development even though some subsystem details have not
    yet been completely defined.  Missing information and related flexibility
    requirements can lead to a design plagued by many well-known problems that
    affect performance, modularity, scalability, and clear separation of
    concerns.  In some cases, developers must sacrifice rules of thumb to
    maintain planned development schedules.  Providing flexibility for
    everything in the system isn't possible, so developers will always need to
    determine the static requirements and explicitly state where continued
    development and rapid modification require flexibility.", 
  location     = "http://dx.doi.org/10.1109/2.963444"
}

@Article{cdsde,
  author       = "{\' A}kos L{\' e}deczi and {\' A}rp{\' a}d Bakay and Mikl{\'
    o}s Mar{\' o}ti and P{\' e}ter V{\" o}lgyesi and Greg Nordstrom and
    Jonathan Sprinkle and G{\' a}bor Karsai", 
  title        = "Composing Domain-Specific Design Environments",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "44--51",
  month        = nov,
  keywords     = "frameworks, static and dynamic semantics, metamodeling",
  abstract     = "Domain-specific integrated development environments can help
    capture specifications in the form of domain models.  These tools support
    the design process by automating analysis and simulating essential system
    behavior.  In addition, they can automatically generate, configure, and
    integrate target application components.  The high cost of developing
    domain-specific, integrated modeling, analysis, and application- generation
    environments prevents their penetration into narrower engineering fields
    that have limited user bases.  Model-integrated computing (MIC), an
    approach to model-based engineering that helps compose domain-specific
    design environments rapidly and cost effectively, is particularly relevant
    for specialized computer-based systems domains--perhaps even single
    projects.  The authors describe how MIC provides a way to compose such
    environments cost effectively and rapidly by using a metalevel architecture
    to specify the domain-specific modeling language and integrity constraints.
    They also discuss the toolset that implements MIC and describe a practical
    application in which using the technology in a tool environment for the
    process industry led to significant reductions in development and
    maintenance costs.",
  location     = "http://dx.doi.org/10.1109/2.963443"
}

@Article{mvins,
  author       = "Robert~A. Martin",
  title        = "Managing Vulnerabilities in Networked Systems",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "32--38",
  month        = nov,
  keywords     = "threat assessment",
  abstract     = "Most organizations recognize the importance of cyber
    security and are implementing various forms of protection.  However, many
    are failing to find and fix known security problems in the software
    packages they use as the building blocks of their networks and systems, a
    vulnerability that a hacker can exploit to by-pass all other efforts to
    secure the enterprise.  The Common Vulnerabilities and Exposures initiative
    seeks to avoid such disasters and transform this area from a liability to a
    key asset in the fight to build and maintain secure systems.  Coordinating
    international, community-based efforts from industry, government, and
    academia, CVE strives to find and fix software product vulnerabilities more
    rapidly, predictably, and efficiently.  The initiative seeks the adoption
    of a common naming practice for describing software vulnerabilities.  Once
    adopted, these names will be included within security tools and services
    and on the fix sites of commercial and open source software package
    providers.  As vendors respond to more user requests for CVE-compatible fix
    sites, securing the enterprise will gradually include the complete cycle of
    finding, analyzing, and fixing vulnerabilities.", 
  location     = "http://dx.doi.org/10.1109/2.963441"
}

@Article{adawc,
  author       = "Andreas Zeller",
  title        = "Automated Debugging: Are We Close",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 11,
  pages        = "26--31",
  month        = nov,
  keywords     = "delta debugging",
  abstract     = "Although software engineers have enjoyed tremendous
    productivity increases as more of their tasks have become automated,
    debugging remains as labor-intensive and painful as it was 50 years ago.
    An engineer or programmer must still set up hypotheses to use in
    identifying and correcting a failure's root cause.  The author describes a
    new algorithm that promises to relieve programmers of the hit-or- miss
    approach to debugging.  Delta Debugging uses the results of automated
    testing to systematically narrow the set of failure-inducing circumstances.
    Programmers supply a test function for each bug and hardcode it into any
    imperative language.  The test function checks a set of changes to
    determine if the failure is present or if the outcome is unresolved, then
    feeds that information to the Delta Debugging code.  As we discover more
    about the structure of these circumstances and the resulting causality
    chain, we come closer to passing much of the boredom and monotony of
    debugging onto machines.  Debugging can be just as disciplined, systematic,
    and quantifiable as any other area of software engineering--which means
    that we should eventually be able to automate at least part of it.
    Ultimately, debugging may become as automated as testing--not only
    detecting failures, but also revealing how they came to be.", 
  location     = "http://dx.doi.org/10.1109/2.963440"
}

@Article{ksotsw,
  author       = "Gregoris Mentzas and Kostas Kafentzis and Panos Georgolios",
  title        = "Knowledge Services on the {S}emantic {W}eb",
  journal      = cacm,
  year         = 2007,
  volume       = 50,
  number       = 10,
  pages        = "53--58",
  month        = oct,
  keywords     = "knowledge trading",
  abstract     = "Developing infrastructures for trading knowledge services
    using semantic technologies.",
  location     = "http://dx.doi.org/10.1145/1290958.1290962"
}

@Article{racgpp,
  author       = "Gary~P. Pisano and Willy~C. Shih",
  title        = "Restoring {A}merican Competitiveness",
  journal      = "Harvard Business Review",
  year         = 2009,
  volume       = "",
  number       = "",
  pages        = "",
  abstract     = "",
  month        = jul # "-" # aug,
  keywords     = "",
  location     = "http://hbr.org/2009/07/restoring-american-competitiveness/ar/1"
}

@Article{trofbrir,
  author       = "Richard Fikes and Tom Kehler",
  title        = "The Role of Frame-Based Representation in Reasoning",
  journal      = cacm,
  year         = 1985,
  volume       = 28,
  number       = 9,
  pages        = "904-920",
  month        = sep,
  keywords     = "frames, knowledge representation",
  abstract     = "A frame-based representation facility contributes to a 
    knowledge system's ability to reason and can assist the system designer in
    determining strategies for controlling the system's reasoning.",
  location     = "http://dx.doi.org/10.1145/4284.4285"
}

@Article{ooptavsb,
  author       = "Mark Stefik and Daniel Bobrow",
  title        = "Object-Oriented Programming: Themes and Variations",
  journal      = "AI Magazine",
  year         = 1986,
  volume       = 6,
  number       = 4,
  pages        = "40--62",
  month        = "Winter",
  keywords     = "",
  abstract     = "",
  location     = ""
}

@Article{bspwodp,
  author       = "Fernando Pedone",
  title        = "Boosting System Performance with Optimistic Distributed Protocols",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "80--86",
  month        = dec,
  keywords     = "distributed protocol, atomic broadcast",
  abstract     = "Optimistic distributed protocols can dramatically improve
    system performance if the underlying system assumptions are sound and carry
    a high degree of probability.  Optimistic protocols aggressively execute
    actions based on best-case system assumptions.  Using optimistic protocols
    unquestionably involves tradeoffs, but if a protocol is well designed and
    the optimistic assumptions hold frequently enough, the gain in performance
    outweighs the overhead of repairing actions that execute incorrectly.
    Demand for high performance under special circumstances in distributed
    settings has led to the development of optimistic distributed protocols in
    recent years.  Indeed, given the right optimistic assumptions and
    mechanisms, optimistic protocols can significantly boost the efficiency of
    a system.  Designing such protocols, however, is still a complicated and
    poorly understood activity.  Part of this complexity is due to the inherent
    complications of distributed protocols and part is due to the lack of
    knowledge about how optimistic protocols should work.  By providing a
    framework to reason about these protocols, this article is a first step
    toward systematizing the construction of optimistic distributed protocols.
    However, much still remains to be understood about how to design their
    underlying mechanisms.",
  location     = "http://dx.doi.org/10.1109/2.970581"
}

@Article{fcdahsem ,
  author       = "Carl~K. Chang and Jane Cleland-Haung and Shiyan Hua and Annie
    Kuntzmann-Combelles", 
  title        = "Function-Class Decomposition: {A} Hybrid Software Engineering Method",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "87--93",
  month        = dec,
  keywords     = "software structure, decomposition",
  abstract     = "In addition to offering a simple yet powerful method for 
    decomposing a system, function-class decomposition (FCD) produces an
    architecture that is more supportive than traditional object-oriented
    decomposition for several software engineering tasks.  A hybrid method that
    integrates structured analysis with an OO approach, FCD identifies classes
    in parallel with decomposing the system into a hierarchy of functional
    modules.  Recently, developers extended FCD to integrate UML concepts.
    Useful for partitioning a system for distribution, the FCD hierarchy
    provides a framework for controlling development in a distributed software
    engineering environment.  It also helps identify and integrate components
    in component-based development and supports the system life-cycle
    maintenance phase.  Further, FCD addresses many of the initial analysis and
    design problems inherent in large and complex OO systems.  The authors'
    experience with testing FCD on several applications validates its
    compatibility with OO methodologies and modeling techniques.  In addition
    to supporting the decomposition process itself, the resulting FCD
    architecture and related artifacts support maintenance of the system in the
    face of changing requirements.",
  location     = "http://dx.doi.org/10.1109/2.970582"
}

@Article{sstodwp,
  author       = "Rob Armstrong",
  title        = "Seven Steps to Optimizing Data Warehouse Performance",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "76--79",
  month        = dec,
  keywords     = "data model, views, indexes, denormalization",
  abstract     = "Most operational systems store data in a normalized model in 
    which certain rules eliminate redundancy and simplify data relationships.
    While beneficial for the online transaction processing workload, this model
    can inhibit those same OLTP databases from running analytical queries
    effectively.  Because the analytical systems did not need to support the
    OLTP workload, many developers began preplanning for the answer sets.
    Preplanning, however, created problems in four areas: creating summary
    tables of preaggregated data, placing indexes in the system to
    eliminatescanning large data volumes, putting data into one table instead
    of having tables that join together, and storing the data in sorted order.
    All these activities require prior knowledge of the analysis and reports
    being requested.  Unfortunately, most data warehouse implementations ignore
    the longer-term goals of analysis and flexibility in the rush to provide
    initial value.  Taking time to consider the project's real purpose, then
    building a correct foundation for it, can assure a better future for the
    data warehouse.  The implementers, not the user community, should decide
    whether to use a summary table or functional model.  However, the users,
    not the IT group, must determine which capability needs must be delivered
    to drive business opportunity.", 
  location     = "http://dx.doi.org/10.1109/2.970580"
}

@Article{ddwwocm ,
  author       = "Juan Trujillo and Manuel Palomar and Jaime Gomez and Il-Yeol
    Song", 
  title        = "Designing Data Warehouses with {OO} Conceptual Models",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "66--75",
  month        = dec,
  keywords     = "multidimensional modeling, conceptual modeling, olap",
  abstract     = "The authors propose an approach that provides a theoretical
     foundation for the use of object-oriented databases and object-relational
     databases in data warehouse, multidimensional database, and online
     analytical processing applications.  This approach introduces a set of
     minimal constraints and extensions to the Unified Modeling Language for
     representing multidimensional modeling properties for these applications.
     Multidimensional modeling offers two benefits.  First, the model closely
     parallels how data analyzers think and, therefore, helps users understand
     data.  Second, multidimensional modeling helps predict what final users
     want to do, thereby facilitating performance improvements.  The authors
     are using their approach to create an automatic implementation of a
     multidimensional model.  They plan to integrate commercial
     online-analytical-processing tool facilities within their GOLD Model Case
     Tool as well, a task that involves data warehouse prototyping and sample
     data generation issues.",
  location     = "http://dx.doi.org/10.1109/2.970579"
}

@Article{hdwaqa,
  author       = "Donald~J. Berndt and John~W. Fisher and Alan~R. Hevner and
    James Studnicki",
  title        = "Healthcare Data Warehousing and Quality Assurance",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "56--65",
  month        = dec,
  keywords     = "data dissemination, data quality",
  abstract     = "Healthcare data warehousing presents unique challenges.  The
    industry is rife with often incompatible medical standards and coding
    schemes that require careful translation.  Healthcare data comes from many
    sources and is delivered in many forms, including published books,
    individual spreadsheets, and several tape or data formats.  Results derived
    from a healthcare data warehouse must be delivered in accessible form to
    diverse stakeholders, including healthcare regulators, physicians, hospital
    administrators, consumers, community activists, and members of the popular
    press.  The industry's widely decentralized and largely autonomous data
    collection efforts make data quality a significant challenge.  Finally, the
    sensitivity of healthcare data makes privacy and security issues paramount.
    Healthcare data warehousing will make rigorous, quantitative information
    available to healthcare decision makers.  The authors describe a fully
    functional healthcare data warehouse used to produce several reports for
    communities throughout Florida.  Building on this work, they're actively
    pursuing a research agenda to enhance technical data warehousing
    capabilities while investigating innovative community and clinical
    healthcare applications.", 
  location     = "http://dx.doi.org/10.1109/2.970578"
}

@Article{dtfdss,
  author       = "Surajit Chaudhuri and Umeshwar Dayal and Venkatesh Ganti",
  title        = "Database Technology for Decision Support Systems",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "48--55",
  month        = dec,
  keywords     = "decision support systems, olap, data mining",
  abstract     = "Decision support systems form the core of business IT 
     infrastructures because they let companies translate business information
     into tangible and lucrative results.  Collecting, maintaining, and
     analyzing large amounts of data, however, involves expensive technical
     challenges that require organizational commitment.  Many commercial tools
     are available for each of the three major data warehousing tasks:
     populating the data warehouse from independent operational databases,
     storing and managing the data, and analyzing the data to make intelligent
     business decisions.  Data cleaning relates to heterogeneous data
     integration, a problem studied for many years.  More work must be done to
     develop domain-independent tools that solve the data cleaning problems
     associated with data warehouse development.  Most data mining research has
     focused on developing algorithms for building more accurate models or
     building models faster.  However, data preparation and mining model
     deployment present several engaging problems that relate specifically to
     achieving better synergy between database systems and data mining
     technology.", 
  location     = "http://dx.doi.org/10.1109/2.970575"
}

@Article{mdttdp,
  author       = "Torben Bach Pedersen and Christian~S. Jensen",
  title        = "Multidimensional Database Technology",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "40--46",
  month        = dec,
  keywords     = "spreadsheets, querying, multidimensional data",
  abstract     = "Multidimensional data-base technology is a key factor in the
    interactive analysis of large amounts of data for decision-making purposes.
    In contrast to previous technologies, these databases view data as
    multidimensional cubes that are particularly well suited for data analysis.
    Multidimensional models categorize data either as facts with associated
    numerical measures or as textual dimensions that characterize the facts.
    Queries aggregate measure values over a range of dimension values to
    provide results such as total sales per month of a given product.
    Multidimensional database technology is being applied to distributed data
    and to new types of data that current technology often cannot adequately
    analyze.  For example, classic techniques such as preaggregation cannot
    ensure fast query response times when data-such as that obtained from
    sensors or GPS-equipped moving objects-changes continuously.
    Multidimensional database technology will increasingly be applied where
    analysis results are fed directly into other systems, thereby eliminating
    humans from the loop.  When coupled with the need for continuous updates,
    this context poses stringent performance requirements not met by current
    technology.", 
  location     = "http://dx.doi.org/10.1109/2.970558"
}

@Article{uarwd,
  author       = "Mazen Zari and Hossein Saiedian and Muhammad Naeem",
  title        = "Understanding and Reducing Web Delays",
  journal      = ieeec,
  year         = 2001,
  volume       = 34,
  number       = 12,
  pages        = "30--37",
  month        = dec,
  keywords     = "latency, dns lookup, server-side processing, document
    transfer, caching architectures, prefetching, load-balancing, content
    distribution",
  abstract     = "Slow performance costs e-commerce Web sites as much as $4.35
    billion annually in lost revenue.  Perceived latency-the amount of time
    between when a user issues a request and receives a response-is a critical
    issue.  Research into improving performance falls into two categories: work
    on servers and work on networks and protocols.  On the server side,
    previous work has focused on techniques for improving server performance.
    Such studies show how Web servers behave under a range of loads.  These
    studies often suggest enhancements to application implementations and the
    operating systems those servers run.  On the network side, research has
    focused on improving network infrastructure performance for Internet
    applications.  Studies focusing on network dynamics have resulted in
    several enhancements to HTTP, including data compression, persistent
    connections, and pipelining.  These improvements are all part of HTTP 1.1.
    However, little work has been done on common latency sources that cause the
    overall delays that frustrate end users.  The future of performance
    improvements lies in developing additional techniques to help implement
    efficient, scalable, and stable improvements that enhance the end-user
    experience.", 
  location     = "http://dx.doi.org/10.1109/2.970554"
}

@Article{rle,
  author       = "Richard Ferri",
  title        = "Remote {L}inux Explained",
  journal      = "Linux Journal",
  year         = 2002,
  volume       = 2002,
  number       = 93,
  pages        = "68--75",
  month        = feb,
  keywords     = "dhcp, remote boot",
  location     = "http://www.linuxjournal.com/article/5465"
}

@Article{ptaarm,
  author       = "Mick Bauer",
  title        = "Practical Threat Analysis and Risk Management",
  journal      = "Linux Journal",
  year         = 2002,
  volume       = 2002,
  number       = 93,
  pages        = "24--31",
  month        = feb,
  keywords     = "vulnerabilities, risk analysis",
  location     = "http://www.linuxjournal.com/article/5567"
}

@Article{eaes,
  author       = "Gabriel Leen and Donal Hefferman",
  title        = "Expanding Automotive Electronic Systems",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "88--93",
  month        = jan,
  keywords     = "in-vehicle networks, bluetooth",
  abstract     = "The past four decades have witnessed an exponential increase
    in the number and sophistication of electronic systems in vehicles.  In
    1977, the value of electronics systems and silicon components-such as
    transistors, microprocessors, and diodes-in motor vehicles averaged $110,
    while in 2001 it had increased to $1,800.  Today, the cost of electronics
    in luxury vehicles can amount to more than 23 percent of the total
    manufacturing cost.  Analysts estimate that more than 80 percent of all
    automotive innovation now stems from electronics.  Today's high-end
    vehicles may have more than 4 kilometers of wiring-compared to 45 meters in
    vehicles manufactured in 1955.  Reducing wiring mass through in-vehicle
    networks will bring an explosion of new functionality and innovation.  Our
    vehicles will become more like PCs, creating the potential for a host of
    plug-and-play devices.  On average, US commuters spend 9 percent of their
    day in an automobile.  Thus, introducing multimedia and telematics to
    vehicles will increase productivity and provide entertainment for millions.
    Further, X-by-wire solutions will make computer diagnostics a standard part
    of mechanics' work and may even create an electronic chauffeur.",
  location     = "http://dx.doi.org/10.1109/2.976923"
}

@Article{apafrqc,
  author       = "Mark Oskin and Frederic~T. Chong and Isaac~L. Chuang",
  title        = "{A} Practical Architecture for Reliable Quantum Computers",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "79--87",
  month        = jan,
  keywords     = "error correction, quantum algorithms, computer architectures",
  abstract     = "Quantum computers offer the prospect of computation that 
    scales exponentially with data size.  Unfortunately, a single bit error can
    corrupt an exponential amount of data.  Quantum mechanics can seem more
    suited to science fiction than system engineering, yet small quantum
    devices of 5 to 7 bits have been built in the laboratory, 100-bit devices
    are on the drawing table now, and emerging quantum technologies promise
    even greater scalability.  Empirical studies of practical quantum
    architectures are just beginning to appear in the literature.  Elementary
    architectural concepts are still lacking: How do we provide quantum
    storage, data paths, classical control circuits, parallelism, and system
    integration? And, crucially, how can we design architectures to reduce
    error-correction overhead? The authors describe a proposed architecture
    that uses code teleportation, quantum memory refresh units, dynamic
    compilation of quantum programs, and scalable error correction to achieve
    system- level efficiencies.  They assert that their work indicates the
    underlying technology's reliability is crucial; practical architectures
    will require quantum technologies with error rates between 10^-6 and 10^-9
    .",
  location     = "http://dx.doi.org/10.1109/2.976922"
}

@Article{nocansp,
  author       = "Luca Benini and Giovanni {De Micheli}",
  title        = "Networks on Chips: {A} New {SoC} Paradigm",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "70--78",
  month        = jan,
  keywords     = "wiring delays, micronetwork architecture, software layers",
  abstract     = "A system on chip (SoC) can provide an integrated solution to 
    challenging design problems in the telecommunications, multimedia, and
    consumer electronics domains.  Much of the progress in these fields hinges
    on the designers' ability to conceive complex electronic engines under
    strong time-to- market pressure.  Success will require using appropriate
    design and process technologies, as well as interconnecting existing
    components reliably in a plug-and-play fashion.  Focusing on using
    probabilistic metrics such as average values or variance to quantify design
    objectives such as performance and power will lead to a major change in SoC
    design methodologies.  Overall, these designs will be based on both
    deterministic and stochastic models.  Creating complex SoCs requires
    modular, component-based approach to both hardware and software design.
    Despite numerous challenges, the authors believe that developers will solve
    the problems of designing SoC networks.  At the same time, they believe
    that a layered-micronetwork design methodology will likely be the only path
    to mastering the complexity of future SoC designs.",
  location     = "http://dx.doi.org/10.1109/2.976921"
}

@Article{grfamwc,
  author       = "Barry Boehm",
  title        = "Get Ready for Agile Methods, with Care",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "64--69",
  month        = jan,
  keywords     = "planning, discipline, software development management",
  abstract     = "A new generation of developers cites the crushing weight of 
    corporate bureaucracy, the rapid pace of information technology change, and
    the dehumanizing effects of detailed plan-driven development as cause for
    revolution.  In their rallying cry, the Manifesto for Agile Software
    Development, these developers call for a revitalized approach to
    development that dispenses with all but the essentials.  Real-world
    examples argue for and against agile methods.  Responding to change has
    been cited as the critical technical success factor in the Internet browser
    battle between Microsoft and Netscape.  But overresponding to change has
    been cited as the source of many software disasters, such as the $3 billion
    overrun of the US Federal Aviation Administration's Advanced Automation
    System for national air traffic control.  The author believes that both
    agile and plan-driven approaches have a responsible center and
    overinterpreting radical fringes.  Agile and plan-driven methods both form
    part of the planning spectrum.  Thus, while each approach has a home ground
    within which it performs very well, and much better than the other, a
    combined approach is feasible and preferable in some circumstances.", 
  location     = "http://dx.doi.org/10.1109/2.976920"
}

@Article{ticnadc,
  author       = "Bruce~R. Schatz",
  title        = "The {I}nterspace: Concept Navigation Across Distributed Communities",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "54--62",
  month        = jan,
  keywords     = "semantic indexing, peer-to-peer networking",
  abstract     = "With the Interspace, the global information infrastructure
    will, for the first time, directly support interaction with abstraction.
    This infrastructure uses technologies that go beyond searching individual
    repositories to analyze and correlate knowledge across multiple sources and
    subjects.  The Interspace will offer distributed services to transfer
    concepts across domains, just as Arpanet used distributed services to
    transfer files across machines and the Internet uses distributed services
    to transfer objects across repositories.  Standard protocols for the
    emerging information infrastructure will support searching knowledge
    collections maintained and indexed by specialized communities and residing
    directly on users' personal machines.  These protocols will automatically
    interconnect related logical spaces, letting individuals navigate across
    community repositories rather than searching for interlinked objects within
    physical networks.  The Community Architectures for Network Information
    Systems Laboratory has developed a working Interspace prototype that uses
    scalable technologies for concept extraction and navigation.  They have
    successfully tested these technologies, which compute contextual frequency
    of document phrases within community repository, on discipline-scale,
    real-world collections.  Within the next decade, semantic indexing will
    extend beyond concepts and categories to perspectives, which relate
    concepts within categories, and situations, which relate categories within
    collections.  These more abstract semantic levels will lead to a closer
    matching of the meanings in the user's mind to the world's objects.",
  location     = "http://dx.doi.org/10.1109/2.976919"
}

@Article{2trfs,
  author       = "Alan Allan and Don Edenfeld and William~H. {Joyner, Jr.} and
    Andrew~B. Kahng and Mike Rodgers and Yervant Zorian",
  title        = "2001 Technology Roadmap for Semiconductors",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "42--53",
  month        = jan,
  keywords     = "scaling, clock frequency, design drivers, soc",
  abstract     = "The International Technology Roadmap for Semiconductors is a 
    worldwide collaborative effort within the semiconductor industry to
    confront the challenges implicit in Moore's law.  The Roadmap's goal is to
    present an industry-wide consensus on the best current estimate of its R&D
    needs out to a 15-year horizon.  As such, the ITRS provides a guide to the
    efforts of companies, research organizations, and governments to improve
    the quality of R&D investment decisions made at all levels.  The 2001
    Roadmap is notable because it was developed with truly international
    representation.  In this article, representatives of the International
    Technology Working Groups for Design and Test showcase some of the
    contributions from 839 international experts seeking to address the
    difficult and exciting challenges facing the design and test communities
    and the semiconductor industry as a whole.", 
  location     = "http://dx.doi.org/10.1109/2.976918"
}

@Article{islwtcom,
  author       = "Chandra Narayanaswami and Noboru Kamijoh and Mandayam
    Raghunath and Tadanobu Inoue and Thomas Cipolla and Jim Sanford and Eugene
    Schlig and Sreekrishnan Venkiteswaran and Dinakar Guniguntala and Vishal
    Kulkarni and Kazuhiko Yamazaki", 
  title        = "{IBM}'s {L}inux Watch: The Challenge of Miniaturization",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 1,
  pages        = "33--41",
  month        = jan,
  keywords     = "miniaturization, protyping",
  abstract     = "Nearly four years in development, the IBM Linux watch
    contains a complete computer system that runs Linux, displays X11 graphics,
    and has wireless connectivity.  The system fits in a case that could pass
    as a slightly unusual analog timepiece with a somewhat odd shape and an
    extraordinarily brilliant face.  The developers have created two versions
    of the watch, one with an organic light-emitting diode display and the
    other with a liquid crystal display.  Still considered a research
    prototype, the watch already runs some personal information management
    applications, and it can communicate with PCs, PDAs, and other
    wireless-enabled devices, viewing condensed e-mail and directly receiving
    pager-like messages.  Eventually, users will be able to access various
    Internet-based services, such as up-to-the-minute information about
    weather, traffic conditions, the stock market, and sports.", 
  location     = "http://dx.doi.org/10.1109/2.976917"
}

@Article{uspftparl,
  author       = "Rory Krause",
  title        = "Using {ssh} Port Forwarding to Print at Remote Locations",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 94,
  pages        = "60--64",
  month        = feb,
  keywords     = "ssh, remote printing",
  location     = "http://www.linuxjournal.com/article/5462"
}

@Article{udagof,
  author       = "Timm Murray",
  title        = "Using {D}ebian {apt-get} over {F}reenet",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 94,
  pages        = "86--88",
  month        = feb,
  keywords     = "package management, debian, peer-to-peer networks, code
    distribution",
  location     = "http://www.linuxjournal.com/article/4847"
}

@Article{suaalwl,
  author       = "Don Marti",
  title        = "Setting up an All-{L}inux Wireless {LAN}",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 94,
  pages        = "66--70",
  month        = feb,
  keywords     = "networking, wireless networks, network management",
  location     = "http://www.linuxjournal.com/article/5470"
}

@Article{vfiwc,
  author       = "Michael Rash",
  title        = "Verifying Filesystem Integrity with {CVS}",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 94,
  pages        = "40--44",
  month        = feb,
  keywords     = "tripwire, cvs, security, intrusion detection",
  location     = "http://www.linuxjournal.com/article/5569"
}

@Article{itlpf,
  author       = "Gianluca Insolvibile",
  title        = "Inside the {L}inux Packet Filter",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 94,
  pages        = "14--18",
  month        = feb,
  keywords     = "packet filters, network protocols, network processing",
  location     = "http://www.linuxjournal.com/article/4852"
}

@Article{bokfsqm,
  author       = "Norman~F. Schneidewind",
  title        = "Body of Knowledge for Software Quality Measurement",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "77--83",
  month        = feb,
  keywords     = "quality engineering, risk analysis",
  abstract     = "Measuring quality is the key to developing high-quality
    software.  The author describes two approaches that help to identify the
    body of knowledge software engineers need to achieve this goal.  The first
    approach derives knowledge requirements from a set of issues identified
    during two standards efforts: the IEEE Std.  1061-1998 for a Software
    Quality Metrics Methodology and the American National Standard Recommended
    Practice for Software Reliability (ANSI /AIAA R-013-1992).  The second
    approach ties these knowledge requirements to phases in the software
    development life cycle.  Together, these approaches define a body of
    knowledge that shows software engineers why and when to measure quality.
    Focusing on the entire software development life cycle, rather than just
    the coding phase, gives software engineers the comprehensive knowledge they
    need to enhance software quality and supports early detection and
    resolution of quality problems.  The integration of product and process
    measurements lets engineers assess the interactions between them throughout
    the life cycle.  Software engineers can apply this body of knowledge as a
    guideline for incorporating quality measurement in their projects.
    Professional licensing and training programs will also find it useful",  
  location     = "http://dx.doi.org/10.1109/2.982919"
}

@Article{aapmf,
  author       = "Joel Emer and Pritpal Ahuja and Eric Borch and Artur Klauser
    and Chi-Keung Luk and Srilatha Manne and Shubhendu~S. Mukherjee and Harish
    Patil and Steven Wallace and Nathan Binkert and Roger Espasa and Toni
    Juan",
  title        = "Asim: {A} Performance Model Framework",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "68--76",
  month        = feb,
  keywords     = "design management, performance models",
  abstract     = "The longevity and usefulness of a microprocessor performance
    model has historically depended on the model writer's skills and
    discipline.  However, at Compaq the models became extremely complex and
    unmanageable because designers lacked a structured way to develop them.  To
    cope with these complexities, Compaq researchers began developing Asim in
    late 1998 to allow model writers to faithfully represent the detailed
    timing of complex modern machines and effectively manage the large software
    projects needed to model such machines.  Asim addresses these needs by
    providing a modular and reusable framework for creating many models.  The
    framework's modularity helps break down the performance-modeling problem
    into individual pieces that can be modeled separately, while its
    reusability allows using a software component repeatedly in different
    contexts", 
  location     = "http://dx.doi.org/10.1109/2.982918"
}

@Article{saifcsm,
  author       = "Todd Austin and Eric Larson and Dan Ernst",
  title        = "{SimpleScalar}: An Infrastructure for Computer System Modeling",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "59--67",
  month        = feb,
  keywords     = "system modeling, execution-driven simulation",
  abstract     = "Designers can execute programs on software models to 
    validate a proposed hardware design's performance and correctness, while
    programmers can use these models to develop and test software before the
    real hardware becomes available.  Three critical requirements drive the
    implementation of a software model: performance, flexibility, and
    detail.Performance determines the amount of workload the model can exercise
    given the machine resources available for simulation.  Flexibility
    indicates how well the model is structured to simplify modification,
    permitting design variants or even completely different designs to be
    modeled with ease.  Detail defines the level of abstraction used to
    implement the model's components.The SimpleScalar tool set provides an
    infrastructure for simulation and architectural modeling.  It can model a
    variety of platforms ranging from simple unpipelined processors to detailed
    dynamically scheduled microarchitectures with multiple-level memory
    hierarchies.  SimpleScalar simulators reproduce computing device operations
    by executing all program instructions using an interpreter.The tool set's
    instruction inter-complex modern machines and effectively manage the large
    software projects needed to model such machines.  Asim addresses these
    needs by providing a modular and reusable framework for creating many
    models.  The framework's modularity helps break down the
    performance-modeling problem into individual pieces that can be modeled
    separately, while its reusability allows using a software component
    repeatedly in different contexts.", 
  location     = "http://dx.doi.org/10.1109/2.982917"
}

@Article{safssp,
  author       = "Peter~S. Magnusson and Magnus Christensson and Jesper
    Eskilson and Daniel Forsgren and Gustav H\a llberg and Johan H{\" o}gberg
    and Fredrik Larsson and Andreas Moestedt and Bengt Werner", 
  title        = "Simics: {A} Full System Simulation Platform",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "50--58",
  month        = feb,
  keywords     = "",
  abstract     = "Full system simulation seeks to strike a balance between
    accuracy and performance.  Many of its possibilities have been obvious to
    practitioners in both academia and industry for quite some time, perhaps
    decades, but Simics supports more of these possibilities within a single
    framework than other tools do.Simics is a platform for full system
    simulation that can run actual firmware and completely unmodified kernel
    and driver code.  It is sufficiently abstract to achieve tolerable
    performance levels, and it provides both functional accuracy for running
    commercial workloads and sufficient timing accuracy to interface to
    detailed hardware models.  Simics can also run a heterogeneous network of
    systems from different vendors within the same framework.  Exceptionally
    fast, Simics can easily add new components and leverage older ones within a
    practical abstraction level.  It offers a platform with a rich API and a
    powerful scripting environment for use in a broad range of applications.", 
  location     = "http://dx.doi.org/10.1109/2.982916"
}

@Article{rssmmwip,
  author       = "Christopher~J. Hughes and Vijay~S. Pai and Parthasarathy
    Ranganathan and Sarita~V. Adve",
  title        = "{RSIM}: Simulating Shared-Memory Multiprocessors with {ILP} Processors",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "40--49",
  month        = feb,
  keywords     = "processor microarchitectures, validation",
  abstract     = "The early 1990s saw several announcements of commercial
    shared-memory systems using processors that aggressively exploited
    instruction-level parallelism (ILP), including the MIPS R10000,
    Hewlett-Packard PA8000, and Intel Pentium Pro.  These processors could
    potentially reduce memory read stalls by over-lapping read latency with
    other operations, possibly changing the nature of performance bottlenecks
    in the system.The authors' experience with Rsim demonstrates that modeling
    ILP features is important even in shared-memory multiprocessor systems.  In
    particular, current simple processor-based approximations cannot model
    significant performance effects for applications exhibiting parallel read
    misses.  Further, recent shared-memory designs such as aggressive
    implementations of sequential consistency use the aggressive ILP-enhancing
    features of modern processors that simple processor-based simulators do not
    model.As microprocessor systems become more complex, the availability of
    shared infrastructure source code is likely to become increasingly crucial.
    The authors plan to release a new Rsim version shortly that will include
    instruction caches, TLBs, multimedia extensions, simultaneous
    multithreading, Rabbit fast simulation mode, and ports to Linux
    platforms.", 
  location     = "http://dx.doi.org/10.1109/2.982915"
}

@Article{etdcsci,
  author       = "Kenneth~L. Kraemer and Jason Dedrick",
  title        = "Enter the Dragon: China's Computer Industry",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "28--36",
  month        = feb,
  keywords     = "industrial policy, computer industry",
  abstract     = "China transformed its economy by shifting from technological
    nationalism to a more pragmatic strategy of developing national
    capabilities in conjunction with multinational corporations.  Consistent
    with this transformation, China has revamped its industrial and technology
    policies to become a major producer of computer hardware and a major market
    for computing products.  In 2000, mainland Chinese purchased more than
    seven million PCs, while computer hardwareproduction grew to $23 billion.
    China's policies clearly drew on the developmental approach of other
    Asia-Pacific countries that became leaders in the global computer industry
    through the strong support of government industrial and technology
    policies.China has likewise become a major force in the global PC industry,
    as both the most attractive growth market and as a large producer.  It has
    done so through a combination of industry promotion and entrepreneurial
    energy.  New challenges loom as China joins the World Trade Organization
    and faces more pressure to open its market to foreign competition.", 
  location     = "http://dx.doi.org/10.1109/2.982913"
}

@Article{acatod,
  author       = "Clyde~W. Holsapple and K.~D. Joshi",
  title        = "{A} Collaborative Approach to Ontology Design",
  journal      = cacm,
  year         = 2002,
  volume       = 45,
  number       = 2,
  pages        = "42--47",
  month        = feb,
  keywords     = "delphi design",
  abstract     = " Creating a general ontology characterizing the conduct of
    knowledge management.",
  location     = "http://dx.doi.org/10.1145/503124.503147"
}

@Article{skmatsw,
  author       = "JinKyu Lee and Shambhu~J. Upadhyaya and H.~Raghav Rao and Raj
    Sharman",
  title        = "Secure Knowledge Management and The {S}emantic {W}eb",
  journal      = cacm,
  year         = 2005,
  volume       = 48,
  number       = 12,
  pages        = "48--54",
  month        = dec,
  keywords     = "knowledge management, encryption",
  abstract     = "Strengthening security within the domain of shared knowledge
    is a critical issue, and great challenge, to businesses today. A number of
    different protocols currently available offer an array of benefits and
    limitations.",
  location     = "http://dx.doi.org/10.1145/1101779.1101808"
}

@Article{mdbtatsw,
  author       = "Juhnyoung Lee",
  title        = "Model-Driven Business Transformation and the {S}emantic {W}eb",
  journal      = cacm,
  year         = 2005,
  volume       = 48,
  number       = 12,
  pages        = "75--77",
  month        = dec,
  keywords     = "semantic web",
  abstract     = " Coupling business and IT models provides a top-down business
    perspective.",
  location     = "http://dx.doi.org/10.1145/1101779.1101813"
}

@Article{itlpfpi,
  author       = "Gianluca Insolvibile",
  title        = "Inside the {L}inux Packet Filter, Part {II}",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 95,
  pages        = "20--25",
  month        = mar,
  keywords     = "packet filters, sockets",
  location     = "http://www.linuxjournal.com/article/5617"
}

@Article{csws,
  author       = "Marco Fioretti",
  title        = "Client-Side Web Scripting",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 95,
  pages        = "68--76",
  month        = mar,
  keywords     = "web scripting, web scraping",
  location     = "http://www.linuxjournal.com/article/5623"
}

@Article{xpanwowa,
  author       = "Cameron Laird",
  title        = "{XSLT} Powers a New Wave of Web Applications",
  journal      = "Linux Journal",
  year         = 2002,
  number       = 95,
  pages        = "60--66",
  month        = mar,
  keywords     = "xslt, xml, tcl",
  location     = "http://www.linuxjournal.com/article/5622"
}

@Article{ansodscpp,
  author       = "Leslie Lamport",
  title        = "{A} New Solution of {D}ijkstra's Concurrent Programming Problem",
  journal      = cacm,
  year         = 1974,
  volume       = 17,
  number       = 8,
  pages        = "453--455",
  month        = aug,
  keywords     = "semaphores, concurrency control",
  abstract     = "A simple solution to the mutual exclusion problem is
    presented which allows the system to continue to operate despite the
    failure of any individual component.",
  location     = "http://dx.doi.org/10.1145/361082.361093"
}

@Article{ronsiftngohs,
  author       = "Frank~G. Halasz",
  title        = "Reflection on {NoteCards}: Seven Issues for the Next Generation of Hypermedia Systems",
  journal      = cacm,
  year         = 1988,
  volume       = 31,
  number       = 7,
  pages        = "836--852",
  month        = jul,
  keywords     = "human factors, hypertext, document management",
  abstract     = "NoteCards, developed by a team at Xerox PARC, was designed 
    to support the task of transforming a chaotic collection of unrelated
    thoughts into an integrated, orderly interpretation of ideas and their
    interconnections.  This article presents NoteCards as a foil against which
    to explore some of the major limitations of the current generation of
    hypermedia systems, and characterizes the issues that must be addressed in
    designing the next generation systems.",
  location     = "http://dx.doi.org/10.1145/48511.48514"
}

@Article{grtiahrte,
  author       = "Dennis~W. Leinbaugh",
  title        = "Guaranteed Response Times in a Hard-Real-Time Environment",
  journal      = tse,
  year         = 1980,
  volume       = "SE-6",
  number       = 1,
  pages        = "85--91",
  month        = jan,
  keywords     = "response time, hard real time, operating systems,
    multiprocessing, real-time programming",
  abstract     = "This paper describes a scheduling algorithm for a set of 
    tasks that guarantees the time within which a task, once started, will
    complete.  A task is started upon receipt of an external signal or the
    completion of other tasks.  Each task has a rxed set of requirements in
    processor time, resources, and device operations needed for completion of
    its various segments.  A worst case analysis of task performance is carried
    out.  An algorithm is developed for determining the response times that can
    be guaranteed for a set of tasks.  Operating system overhead is also
    accounted for.", 
  location     = "http://dx.doi.org/10.1109/TSE.1980.234465"
}

@Article{paetbp,
  author       = "Eduardo Miranda",
  title        = "Planning and Executing Time-Bound Projects",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "73--79",
  month        = mar,
  keywords     = "task uncertainties, progress measurement, spid, project
    planning, project control",
  abstract     = "A time-bound project is constrained by hard deadlines, in
    which the delivery's timing is as important as the delivery itself.
    Because most time-bound projects start with more requirements than
    developers can handle within the imposed time constraints, requirements
    often must be slashed halfway through the project, resulting in missed
    deadlines, customer frustration, and wasted effort.  A better approach
    defines requirement priorities before the project's start.  But failing to
    prioritize requirements is not the only reason that projects miss
    deadlines.Traditional planning methods' inability to deal with uncertain
    estimates and their failure to recognize that development work does not
    progress linearly are also to blame.  Statistically Planned Incremental
    Deliveries offer an approach that addresses these problems by combining
    ideas from critical chain planning, incremental development, and rate
    monitoring into a practical method for planning and executing time-bound
    projects.", 
  location     = "http://dx.doi.org/10.1109/2.989933"
}

@Article{soaiowc,
  author       = "Gary William Flake and Steve Lawrence and C.~Lee Giles and
    Frans~M. Coetzee", 
  title        = "Self-Organization and Identification of Web Communities",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "66--71",
  month        = mar,
  keywords     = "web communities, maximum flow communities, graphs",
  abstract     = "Millions of individuals operating independently author the 
    Web's information.  Despite its decentralized nature, the authors' work
    shows that the Web self-organizes and its link structure allows efficient
    identification of communities.  This is significant because no central
    authority or process governs hyperlink formation and structure.A Web
    community is a collection of Web pages in which each member page has more
    hyperlinks within the community than outside it.  Compared to previous
    methods of finding related Web pages,the authors describe an approach that
    retains the transparency of methods such as cocitation and bibliographic
    coupling in explaining why pages belong to a community,yet can identify Web
    communities of arbitrary dimensions.  Applications of their method include
    creating improved search engines, content filtering, and objective analysis
    of Web content and the relationships between Web communities.", 
  location     = "http://dx.doi.org/10.1109/2.989932"
}

@Article{eicsja,
  author       = "Jennifer Allanson",
  title        = "Electrophysiologically Interactive Computer Systems",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "60--65",
  month        = mar,
  keywords     = "epics",
  abstract     = "Modern physiologic data detection relies on the direct 
    application of sensors to the body's surface.Electrophysiologically
    interactive computer systems combine physiological sensing technologies
    with interactive computer applications to support diverse monitoring and
    training disciplines,including systems design and evaluation,medical
    diagnostics and rehabilitation,hazardous awareness monitoring,
    psychophysiological conditioning, dynamic interface reconfiguration, and
    affective computing.  They provide usability metrics and form the backbone
    of brain-computer interfaces, prosthetics, and other hands-free control
    technologies.The author has identified two basic electrophysiologically
    interactive systems:Monitoring systems quantify or measure an
    electrophysiologic signal of interest against some scale, such as the
    direct measurement of blood pressure or the continuous monitoring of heart
    rate over a specified period of time.  Training systems feed back
    physiologic information to a subject in real time to enable operant
    conditioning or instrumental learning of control to occur a process
    commonly known as biofeedback.", 
  location     = "http://dx.doi.org/10.1109/2.989931"
}

@Article{alffcaum,
  author       = "Kurt~D. Fenstermacher and Mark Ginsburg",
  title        = "{A} Lightweight Framework for Cross-Application User Monitoring",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "51--59",
  month        = mar,
  keywords     = "application monitoring, user behavior",
  abstract     = "Users often shift among applications as they seek needed 
    data, integrating new material into e-mail messages, memos, and other
    documents.Unfortunately, the only record of this activity is a series of
    newly created files.The authors propose a lightweight framework for rich
    monitoring of multiapplication client sessions that captures
    allcross-application activity.  This framework enables complex analyses of
    how users access and create information, even when they do so using several
    applications in concert.  Implemented in the Python programming language on
    the Windows platform,the framework provides the infrastructure for
    implementing techniques to assist individual and group knowledge tasks.
    Users can apply it to build understanding in two major ways: monitoring
    information resource usage and analyzing how people use applications and
    tools.", 
  location     = ""
}

@Article{dagari,
  author       = "Ivan Poupyrev and Desney~S. Tan and Mark Billinghurst and
    Hirokazu Kato and Holger Regenbrecht and Nobuji Tetsutani",
  title        = "Developing a Generic Augmented-Reality Interface",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "44-50",
  month        = mar,
  keywords     = "interface design, storyboarding",
  abstract     = "An augmented-reality interface dynamically superimposes
    interactive computer graphics images onto objects in the real world.
    Although researchers and developers have made great advances in display and
    tracking technologies, to date interaction with these environments has been
    largely limited to passive viewing or simple browsing of virtual
    information registered to the real world.The authors designed Tiles as a
    first step toward overcoming these limitations by allowing effective
    spatial composition, layout, and arrangement of digital objects in the
    physical environment.  Tiles users can freely place interface elements
    anywhere they want: on tables or whiteboards, inboxes and folders, arranged
    in stacks, or grouped together.  The interface configuration and layout of
    Tiles' elements emerges spontaneously as the result of users' work activity
    and evolves together with it.", 
  location     = "http://dx.doi.org/10.1109/2.989929"
}

@Article{tpfbt,
  author       = "Andr{\' e} Gu{\' e}ziec",
  title        = "Tracking Pitches for Broadcast Television",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "38--43",
  month        = mar,
  keywords     = "real-time tracking, baseball, video tracking",
  abstract     = "During the 2001 major league baseball season, the strike
    zone received special attention when officials decided to enforce the
    game's original definition, which made tracking pitches especially
    important.  Tracking the flight of a pitch during a live broadcast presents
    two major challenges, however: speed and image-processing
    reliability.Meeting these challenges required developing a complex system
    that fuses high-end computer graphics with a sophisticated algorithm for
    calculating flight trajectories.  ESPN's K Zone pitch-tracking system uses
    computer-generated graphics to create a shaded, translucent box that
    outlines the strike zone boundaries for viewers.  Behind the flashy
    graphics, K Zone provides a sophisticated computing subsystem that monitors
    each pitch's trajectory.  Its development model may well prove effective in
    future computer vision projects, regardless of the application domain.", 
  location     = ""
}

@Article{uctacjd,
  author       = "Roslin~V. Hauck and Homa Atabakhsh and Pichai Ongvasith and
    Harsh Gupta and Hsinchun Chen", 
  title        = "Using {C}oplink to Analyze Criminal-Justice Data",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 3,
  pages        = "30--37",
  month        = mar,
  keywords     = "coplink, concept spaces, user evaluations, co-occurrence
    analysis",
  abstract     = "In criminal justice systems, incompatible content and 
    information formats often create barriers to data accessand utilization
    that make knowledgemanagement a complex and daunting process.  To address
    these problems, the authors undertook the Coplink project,which bridges the
    gap between conducting technology research and helping police officers
    fight crime.University of Arizona researchers originally generated the
    concept space approach to facilitate semantic retrieval of information.
    Although Coplink's current incarnation demonstrates its potential as a tool
    for enhancing the effectiveness of law enforcement, new technologies will
    provide opportunities for making the system even more useful.Meanwhile,
    several user studies have shown that this system also improves searching
    and browsing in the engineering and biomedicine domains.", 
  location     = ""
}

@Article{craw,
  author       = "Leslie Lamport",
  title        = "Concurrent Reading and Writing",
  journal      = cacm,
  year         = 1977,
  volume       = 20,
  number       = 11,
  pages        = "806--811",
  month        = nov,
  keywords     = "shared data, message buffers, mailboxes, generalized readers
    and writes",
  abstract     = "The problem of sharing data among asynchronous processes is 
    considered.  It is assumed that only one process at a time can modify the
    data, but concurrent reading and writing is permitted.  Two general
    theorems are proved, and some algorithms are presented to illustrate their
    use.  These include a solution to the general problem in which a read is
    repeated if it might have obtained an incorrect result, and two techniques
    for transmitting messages between processes.  These solutions do not assume
    any synchronizing mechanism other than data which can be written by one
    process and read by other processes.", 
  location     = "http://dx.doi.org/10.1145/359863.359878"
}

@Article{trailati,
  author       = "Mary Shaw and William~A. Wulf",
  title        = "Towards Relaxing Assumptions in Languages and Their Implementations",
  journal      = sigplan,
  year         = 1980,
  volume       = 15,
  number       = 3,
  pages        = "45--61",
  month        = mar,
  keywords     = "language design, loop control, storage management, procedure
    invocation",
  abstract     = "Language implementors frequently make pre-emptive decisions
    concerning the exact implementations of language features.  These decisions
    constrain programmers' control over their computations and may tempt them
    to write involuted code to obtain special (or efficient) effects.  In many
    cases, we can distinguish some properties of a language facility that are
    essential to the semantics and other properties that are incidental.
    Recent abstraction techniques emphasize dealing with such distinctions by
    separating the properties that are necessary to preserve the semantics from
    the details for which some decision must be made but many choices are
    adequate.  We suggest here that these abstraction techniques can be applied
    to the problem of pre-emptive language decisions by specifying the
    essential properties of languages facilities in a skeleton based language
    and defining interfaces that will accept a variety of implementations that
    differ in other details.",
  location     = "http://dx.doi.org/10.1145/947626.947629"
}

@Article{bavcrj,
  author       = "Jeremy Impson",
  title        = "Build a Virtual {CD}-{ROM} Jukebox",
  journal      = lj,
  year         = 2002,
  number       = 96,
  pages        = "58--60",
  month        = apr,
  keywords     = "cd-jukeboxes, automounting, nfs",
  location     = "http://www.linuxjournal.com/article/5639"
}

@Article{hsmblj,
  author       = "Mick Bauer",
  title        = "Hardening Sendmail",
  journal      = lj,
  year         = 2002,
  number       = 96,
  pages        = "32--40",
  month        = apr,
  keywords     = "sendmail, system administration",
  location     = "http://www.linuxjournal.com/article/5753"
}

@Article{sseat,
  author       = "Richard~H. Thayer",
  title        = "Software System Engineering: {A} Tutorial",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 4,
  pages        = "68--73",
  month        = apr,
  keywords     = "system engineering, software engineering, project management,
    requirements analysis, software design, process planning and control",
  abstract     = "Software, the dominant technology in many technical systems,
    often provides the cohesiveness and data control that enable a complex
    system to solve problems.  Yet the vast majority of large software systems
    do not meet their projected schedule or estimated cost, nor do they
    completely fulfill the system acquirer's expectations.The application of
    system engineering principles to software development produces activities,
    tasks, and procedures called software system engineering, or SwSE - a
    distinct and powerful tool for managing the technical development of large
    software projects.  This tutorial integrates the definitions and processes
    from the IEEE software engineering standards into the SwSE process.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.993773"
}

@Article{fmrtkm,
  author       = "Pedro~J. Moreno and J-M. {Van Thong} and Beth Logan and
    Gareth J.~F. Jones", 
  title        = "From Multimedia Retrieval to Knowledge Management",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 4,
  pages        = "58--66",
  month        = apr,
  keywords     = "speech technologies, speech recognition, ",
  abstract     = "Despite recent advances, multimedia use in knowledge
    management remains largely limited to retrieval systems.  Multimedia data
    introduces several challenges to KM systems, including the uncertainties
    associated with media analyzers and the need for good scalability and
    effective user interfaces.  Architectures capable of handling system
    complexity will also play a crucial role in deploying multimedia-based KM
    solutions.  The prospects for fully exploiting multimedia content are
    promising.  Given current trends in audio and video analysis, multimedia
    storage and distribution over the Internet, developments in XML
    representations, and integration with knowledge portals, the authors expect
    multimedia data to become truly pervasive.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.993772"
}

@Article{ansd,
  author       = "Allen~L. Gorin and Alicia Abella and Tirso Alonso and
    Giuseppe Riccardi and Jeremy~H. Wright",
  title        = "Automated Natural Spoken Dialog",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 4,
  pages        = "51--56",
  month        = apr,
  keywords     = "call classification, dialog management, language complexity",
  abstract     = "Traditional menu-driven speech recognition systems force
    users to learn the machine's jargon, but many people can't or won't
    navigate such highly structured interactions.  AT&T's How May I Help You?
    technology shifts the burden to the machine by requiring it to adapt to
    human language and understand what people actually say rather than what a
    system designer expects them to say.  For a given task, it is more crucial
    to recognize and understand some linguistic events than others.  The
    authors have developed algorithms that automatically learn the salient
    words, phrases, and grammar fragments for a given task far more reliably
    than other methods.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.993771"
}

@Article{lvsra,
  author       = "Mukund Padmanabhan and Michael Picheny",
  title        = "Large-Vocabulary Speech Recognition Algorithms",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 4,
  pages        = "42--50",
  month        = apr,
  keywords     = "feature vectors, hypothesis search, acoustic models",
  abstract     = "Providing the computer with a natural interface, including
    the ability to understand human speech, has been a research goal for almost
    40 years.  Practical versions of such systems have become moderately usable
    and commercially successful only in the past few years, however.  To date,
    statistical modeling techniques trained from hundreds of hours of speech
    have provided most speech recognition advancements.  Although it may appear
    that we have far to go before these systems can match human performance, if
    researchers maintain the current rate of yearly progress in reducing word
    error rates, that objective should be within reach in less than a decade.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.993770"
}

@Article{tfia,
  author       = "Donald Welch and Daniel Ragsdale and Wayne Schepens",
  title        = "Training for Information Assurance",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 4,
  pages        = "30--37",
  month        = apr,
  keywords     = "defence, war games",
  abstract     = "The US is at great risk from terrorist manipulation of the
    intangible bits and bytes of cyberspace.  US military institutions are
    already preparing for cyberspace terrorism and warfare by educating cadets
    in information assurance.  In January 2000, the US Military Academy at West
    Point created an information assurance course that centers on a
    competitive, hands-on defensive project: protect a real network from real
    attack.This project forced the cadets to pull together what they know
    theoretically and apply it to a real network under attack without risking
    the damage that mistakes would cause on a live network.The authors
    encourage other organizations to follow their lead by conducting similar
    competitive exercises.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.993768"
}

@Article{oftpdap,
  author       = "Nachiketh~R. Potlapally",
  title        = "Optical Fingerprinting to Protect Data: {A} Proposal",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 4,
  pages        = "23--28",
  month        = apr,
  keywords     = "drm, tamper resistance, optical disks, smart cards",
  abstract     = "The pervasive use of optical discs-the preferred media for 
    storing and distributing digital information-is motivated by their low
    cost, versatility,and durability.  Unfortunately, circuit technology
    advances have made it easy to create high-fidelity copies of these discs.
    The trend toward progressive easeof disc copying has spawned a burgeoning
    parallel economy based on illegal software copying and merchandizing.Thor
    is a proposed security scheme to prevent unauthorized disc duplication and
    illegal use of the data.  Thor relies on a combination of software and
    hardware strategies using time-tested cryptographic algorithms to provide
    resistance to tampering and malicious operations.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.993767"
}

@Article{tdaiotldfl,
  author       = "Jeffrey~H. Kingston",
  title        = "The Design and Implementation of the {L}out Document Formatting Language",
  journal      = spe,
  year         = 1993,
  volume       = 23,
  number       = 9,
  pages        = "1001--1041",
  month        = sep,
  keywords     = "document formatting, typesetting, language design",
  abstract     = "Lout is a high-level language for document formatting, whose
    ease of use has permitted an unprecedented number of advanced features to
    be added quickly and reliably. This paper charts the evolution of the
    design and implementation of Lout from conception in mid-1984 to public
    release in October 1991. It includes extensive discussions of remaining
    problems and possible solutions.",
  location     = "QA 76.5.S653"
}

@Article{kadpij,
  author       = "Joseph Gil and Keren Lenza",
  title        = "Keyword- and Default-Parameters in {J}ava",
  journal      = jot,
  year         = 2012,
  volume       = 11,
  number       = 1,
  pages        = "1--17",
  month        = apr,
  keywords     = "Java, overloading, compiler extension, default parameters,
    keyword parameters",
  abstract     = "Overloading is a highly controversial programming language
    mechanism by which different methods of the same class are allowed to bear
    the same name.  Despite the criticism, Java programmers make extensive use
    of this mechanism---not just because it is available, but also because the
    language does not provide an alternative for defining multiple
    constructors, and because it is useful for expressing similarity of
    services provided by a class.  In a previous paper we argued that more than
    60% of the overloading cases are justifiable and that in 35% of the cases
    overloading is used for emulating a default arguments mechanism.  Based on
    these results, this paper argues that most justifiable uses of overloading
    are better done with a combination of keyword parameters and default
    parameters parameter definition mechanisms, and describes our extension of
    the Java compiler which adds these two features to the language.", 
  location     = "http://www.jot.fm/contents/issue_2012_04/article1.html"
}

@Article{emcpab,
  author       = "Peter~A. Buhr and Richard~C. Bilson",
  title        = "Examining $\mu$" # cpp,
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "36--40",
  month        = feb,
  keywords     = "concurrency, coroutines, monitors, c++",
  location     = "http://www.drdobbs.com/cpp/184406431"
}

@Article{aajax,
  author       = "Eric~J. Bruno",
  title        = "Ajax: Asynchronous {JavaScript} and {XML}",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "32--35",
  month        = feb,
  keywords     = "ajax, html"
}

@Article{dkmwumli,
  author       = "David Frascone",
  title        = "Debugging Kernel Modules with User-Mode {L}inux",
  journal      = lj,
  year         = 2002,
  number       = 97,
  pages        = "76--81",
  month        = may,
  keywords     = "virtual machines, kernel debugging, device drivers",
  location     = "http://www.linuxjournal.com/article/5749"
}

@Article{aftfstl,
  author       = "Stefan B{\" u}ttcher and Charles L.~A. Clarke",
  title        = "Adding Full-Text Filesystem Search to {L}inux",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 3,
  pages        = "28--33",
  month        = jun,
  keywords     = "search, file systems, event notification",
  location     = "https://www.usenix.org/publications/login/june-2006-volume-31-number-3/adding-full-text-filesystem-search-linux"
}

@Article{itz,
  author       = "Tom Haynes",
  title        = "Introduction to {ZFS}",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 3,
  pages        = "20--26",
  month        = jun,
  keywords     = "zfs, zones, file systems",
  location     = "https://www.usenix.org/publications/login/june-2006-volume-31-number-3/introduction-zfs"
}

@Article{cspagthtw,
  author       = "Julie Vore",
  title        = "College Saving Plans:  {A} Guide to How They Work",
  journal      = "AAII Journal",
  year         = 2000,
  pages        = "11--14",
  abstract     = "",
  month        = feb,
  keywords     = "529 plans, saving",
  location     = ""
}

@Article{weiskamf,
  author       = "John Markese",
  title        = "What Every Investor Should Know About Mutual Funds",
  journal      = "AAII Journal",
  year         = 2000,
  pages        = "8--10",
  month        = feb,
  keywords     = "size, expense, loads, ",
  location     = ""
}

@Article{tpbcim,
  author       = "R.~Douglas {Van Eaton}",
  title        = "The Psychology Behind Common Investor Mistakes",
  journal      = "AAII Journal",
  year         = 2000,
  pages        = "2--5",
  month        = apr,
  keywords     = "overconfidence, fear, regret, cognitive dissonance,
    anchoring, representativeness, risk aversion",
  location     = ""
}

@Article{acoddfec,
  author       = "Kurt Chan",
  title        = "{A} Comparison of Disk Drives for Enterprise Computing",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 3,
  pages        = "10--17",
  month        = jun,
  keywords     = "economics, capacity, power, reliability, performance, fibre
    channel, sata, sas",
  location     = "https://www.usenix.org/publications/login/june-2006-volume-31-number-3/comparison-disk-drives-enterprise-computing"
}

@Article{dftpoafs,
  author       = "Marshall Kirk McKusick",
  title        = "Disk from the Perspective of a File System",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 3,
  pages        = "18--19",
  month        = jun,
  keywords     = "freebsd, ",
  location     = "https://www.usenix.org/publications/login/june-2006-volume-31-number-3/disks-perspective-file-system"
}

@Article{aft2c,
  author       = "Stephen~C. Johnson",
  title        = "Algorithms for the 21st Century",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "6--12",
  month        = oct,
  keywords     = "algorithm analysis, timing, data io, layout",
  location     = "https://www.usenix.org/publications/login/october-2006-volume-31-number-5/algorithms-21st-century"
}

@Article{wtiratcos,
  author       = "Jennifer Openshaw",
  title        = "What the Indexes Reveal About the Characteristics of Style",
  journal      = "AAII Journal",
  year         = 1999,
  pages        = "19--22",
  month        = apr,
  keywords     = "investment style, performance trends",
  abstract     = "Market Indexes: Portfolios that follow a particular style
    tend to favor certain industries and do better during certain economic
    environments. An examination of the characteristics of growth and value
    style indexes.",
  location     = "http://www.aaii.com/journal/article/what-the-indexes-reveal-about-the-characteristics-of-style"
}

@Article{taolc,
  author       = "Michael Bacarella",
  title        = "Taking Advantage of {L}inux Capabilities",
  journal      = lj,
  year         = 2002,
  number       = 97,
  pages        = "72--75",
  month        = may,
  keywords     = "proc interface, system call interface, filesystem interface",
  location     = "http://www.linuxjournal.com/article/5737"
}

@Article{tldftirnae,
  author       = "Mary Shaw and Paul Hilfinger and Wm.~A. Wulf",
  title        = "{TARTAN} --- Language Design for the {I}ronman Requirement: Notes and Examples",
  journal      = sigplan,
  year         = 1978,
  volume       = 13,
  number       = 9,
  pages        = "59--75",
  month        = sep,
  abstract     = "The Tartan language was designed as an experiment to see
    whether the Ironman requirement for a common high-order programming
    language could be satisfied by an extremely simple language.  The result,
    Tartan substantially meets the Ironman requirement.  We believe it is
    substantially simpler than the four designs that were done in the first
    phase of the DOD-1 effort.  The language definition appears in a companion
    report; this report provides a more expository discussion of some of the
    language's features, some examples of its use, and a discussion of some
    facilities that could enhance the basic design at relatively little cost.",
  keywords     = "modules, routines, vocabulary, language design",
  location     = "http://repository.cmu.edu/compsci/1500/"
}

@Article{lpfbybp,
  author       = "Albert~J. Fredman",
  title        = "Loan-Participation Funds:  Broadening Your Bond Portfolio",
  journal      = "AAII Journal",
  year         = 1999,
  pages        = "6--10",
  month        = oct,
  keywords     = "senior loans, loan funds, continuous offered funds,
    exchange-traded funds, performance evaluation, loan-fund analysis",
  abstract     = "Mutual Funds: These closed-end funds package participations
    in senior, secured floating-rate bank loans, and as ultra-short-term bond
    portfolios, they have virtually no interest-rate risk.",
  location     = "http://www.aaii.com/journal/article/loan-participation-funds-broadening-your-bond-portfolio"
}

@Article{n2itpoyh,
  author       = "David~A. Bandel",
  title        = "Netfilter 2: in the {POM} of Your Hands",
  journal      = lj,
  year         = 2002,
  number       = 97,
  pages        = "65--70",
  month        = may,
  keywords     = "iptables, firewalls",
  location     = "http://www.linuxjournal.com/article/5660"
}

@Article{affsfu,
  author       = "Marshall~K. McKusick and William~N. Joy and Samuel~J. Leffler
    and Robert~S. Fabry",
  title        = "{A} Fast File System for {UNIX}",
  journal      = tocs,
  year         = 1984,
  volume       = 2,
  number       = 3,
  pages        = "181--197",
  month        = aug,
  keywords     = "unix, file system organization, file system performance, file
    system design, application program interface",
  abstract     = "A reimplementation of the UNIX file system is described.
    The reimplementation provides substantially higher throughput rates by
    using more flexible allocation policies that allow better locality of
    reference and can be adapted to a wide range of peripheral and processor
    characteristics.  The new file system clusters data that is sequentially
    accessed and provides two block sizes to allow fast access to large files
    while not wasting large amounts of space for small files.  File access
    rates of up to ten times faster than the traditional UNIX file system are
    experienced.  Long needed enhancements to the programmers' interface are
    discussed.  These include a mechanism to place advisory locks on files,
    extensions of the name space across file systems, the ability to use long
    filenames, and provisions for administrative control of resource usage.", 
  location     = "http://www.google.com/url?q=http://solarisinternals.com/si/reading/ffs.pdf"
}

@Article{htphpdfw,
  author       = "Greg Kroah-Hartman",
  title        = "How the {PCI} Hot Plug Driver Filesystem Works",
  journal      = lj,
  year         = 2002,
  number       = 97,
  pages        = "54--63",
  month        = may,
  keywords     = "hot plugging, file systems",
  location     = "http://www.linuxjournal.com/article/5633"
}

@Article{lliliapk,
  author       = "Robert Love",
  title        = "Lowering Latency in {L}inux:  Introducing a Preemptible Kernel",
  journal      = lj,
  year         = 2002,
  number       = 97,
  pages        = "48--52",
  month        = may,
  keywords     = "latency, preemptible kernel",
  location     = "http://www.linuxjournal.com/article/5600"
}

@Article{tifalcpi,
  author       = "Robert~J. Fredman",
  title        = "The Index Fund Advantage: Low-Cost Passive Investing",
  journal      = "AAII Journal",
  year         = 1999,
  pages        = "6--10",
  month        = may,
  keywords     = "indexing, costs, zero-sum games, inefficient markets, style
    drift",
  abstract     = "Mutual Funds: Index funds are a plain-vanilla investment that
    offer disciplined individuals rock-bottom costs, tax efficiency, style
    consistency, and a chance to beat the majority of actively managed funds
    over the long haul.",
  location     = "http://www.aaii.com/journal/article/the-index-fund-advantage-low-cost-passive-investing"
}

@Article{umltiav,
  author       = "Kevin Stock and Louis-No{\" e}l Pouchet and P.~Sadayappan",
  title        = "Using Machine Learning to Improve Automatic Vectorization",
  journal      = "ACM Transactions on Architecture and Code Optimization",
  year         = 2012,
  volume       = 8,
  number       = 4,
  month        = jan,
  keywords     = "vectorization, compiler optimization, machine learning",
  abstract     = "Automatic vectorization is critical to enhancing performance
    of compute-intensive programs on modern processors.  However, there is much
    room for improvement over the auto-vectorization capabilities of current
    production compilers through careful vector-code synthesis that utilizes a
    variety of loop transformations (e.g., unroll-and-jam, interchange, etc.).
    As the set of transformations considered is increased, the selection of the
    most effective combination of transformations becomes a significant
    challenge: Currently used cost models in vectorizing compilers are often
    unable to identify the best choices.  In this paper, we address this
    problem using machine learning models to predict the performance of SIMD
    codes.  In contrast to existing approaches that have used high-level
    features of the program, we develop machine learning models based on
    features extracted from the generated assembly code.  The models are
    trained offline on a number of benchmarks and used at compile-time to
    discriminate between numerous possible vectorized variants generated from
    the input code.  We demonstrate the effectiveness of the machine learning
    model by using it to guide automatic vectorization on a variety of tensor
    contraction kernels, with improvements ranging from 2× to 8× over Intel
    ICC's auto-vectorized code.  We also evaluate the effectiveness of the
    model on a number of stencil computations and show good improvement over
    auto-vectorized code.",
  location     = "http://www.cse.ohio-state.edu/~pouchet/doc/taco-article.12.pdf"
}

@Article{sgt,
  author       = "Eytan Suchard and Raviv Yatom and Eitan Shapir",
  title        = "Sudoku \& Graph Theory",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "56--57",
  month        = feb,
  keywords     = "sudoku, graphs",
  location     = "http://www.drdobbs.com/windows/184406436"
}

@Article{dijw,
  author       = "Jeremy Weiskotten",
  title        = "Dependency Injection",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "10--15",
  month        = may,
  keywords     = "unit tests, interfaces, ",
  location     = "http://www.drdobbs.com/tools/185300375"
}

@Article{pdsw,
  author       = "Stefan W{\" o}rthm{\" u}ller",
  title        = "Postmortem Debugging",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "18--21",
  month        = may,
  keywords     = "stacks, logs",
  location     = "http://www.drdobbs.com/tools/185300375"
}

@Article{paomp,
  author       = "Gary Carleton and Walter Shands",
  title        = "Performance Analysis on Multicore Processors",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "22--28",
  month        = may,
  keywords     = "threading, cpu architecture, hotspot analysis, call graphs,
    load balancing, hyperthreading, multithreading",
  location     = "http://www.drdobbs.com/parallel/184417069"
}

@Article{iusjk,
  author       = "John Keogh",
  title        = "Incrementally Updating Software",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "30--36",
  month        = may,
  keywords     = "software updating, live updates, deployment",
  location     = "http://www.drdobbs.com/jvm/185300006"
}

@Article{dsldw,
  author       = "Griffin Caprio",
  title        = "Domain-Specific Languages \& {DSL} Workbench",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "38--41",
  month        = may,
  keywords     = "language design, tool support, software product line",
  location     = ""
}

@Article{itrh,
  author       = "Ralf Holly",
  title        = "{I}, Testbot",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "42--44",
  month        = may,
  keywords     = "testbots",
  location     = "http://www.drdobbs.com/embedded-systems/185300349"
}

@Article{mhwd,
  author       = "Anthony Williams",
  title        = "Message Handling Without Dependencies",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "48--51",
  month        = may,
  keywords     = "dynamic double dispatch, message passing",
  location     = "http://www.drdobbs.com/cpp/184429055"
}

@Article{cgcwassae,
  author       = "Simon Garfinkel",
  title        = "Commodity Grid Computing with {A}mazon's {S3} and {EC2}",
  journal      = login,
  year         = 2007,
  volume       = 32,
  number       = 1,
  pages        = "7--13",
  month        = feb,
  keywords     = "cloud computing, performance, security, rest",
  abstract     = "",
  location     = ""
}

@Article{rtafros,
  author       = "Jorrit~N. Herder and Herbert Bos and Ben Gras and Philip
    Homburg and Andrew~S. Tanenbaum",
  title        = "Roadmap to a Failure-Resilient Operating System",
  journal      = login,
  year         = 2006,
  volume       = 32,
  number       = 1,
  pages        = "14--20",
  month        = feb,
  keywords     = "minix 3, fault resilience, fault isolation, defect
    detection, recovery, ", 
  location     = "https://www.usenix.org/publications/login/february-2007-volume-32-number-1/roadmap-failure-resilient-operating-system"
}

@Article{hvwx,
  author       = "Leigh Griffin and John Ronan",
  title        = "Hardware Virtualization with {X}en",
  journal      = login,
  year         = 2006,
  volume       = 32,
  number       = 1,
  pages        = "21--27",
  month        = feb,
  keywords     = "virtualization, hardware, page tables",
  location     = "https://www.usenix.org/publications/login/february-2007-volume-32-number-1/xen-installation-and-configuration"
}

@Article{cmmamp4tsniowu,
  author       = "Mark Burgess",
  title        = "Configuration Management: Models and Myths. Part 4: There's No {I}\slash{O} Without {U}",
  journal      = login,
  year         = 2006,
  volume       = 32,
  number       = 1,
  pages        = "28--36",
  month        = feb,
  keywords     = "networks, complexity, centralization, symbolic computing,
    economics, autonomic computing, automatic regulation",
  location     = "https://www.usenix.org/publications/login/february-2007-volume-32-number-1/configuration-management-models-and-myths-part-4"
}

@Article{xiac,
  author       = "Leigh Griffin and John Ronan",
  title        = "Xen Installation and Configuration",
  journal      = login,
  year         = 2006,
  volume       = 32,
  number       = 1,
  pages        = "37--43",
  month        = feb,
  keywords     = "xen, virtualization, domains, bootstrapping, virtual domains",
  location     = "https://www.usenix.org/publications/login/february-2007-volume-32-number-1/xen-installation-and-configuration"
}

@Article{dafpwpm,
  author       = "Robert Marmorstein and Phil Kearns",
  title        = "Debugging a Firewall Policy with Policy Mapping",
  journal      = login,
  year         = 2006,
  volume       = 32,
  number       = 1,
  pages        = "44--51",
  month        = feb,
  keywords     = "firewalls, debugging, rule sets",
  location     = "https://www.usenix.org/publications/login/february-2007-volume-32-number-1/debugging-firewall-policy-policy-mapping"
}

@Article{gmofntswacl,
  author       = "Marcus~W. Roberts",
  title        = "Gross Margins: One Financial Number That's Worth a Closer Look",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 6,
  pages        = "2--5",
  month        = jul,
  keywords     = "gross margins, stock selection"
}

@Article{etfantoii,
  author       = "Albert~J. Fredman",
  title        = "Exchange-Traded Funds: {A} New Twist on Index Investing",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 6,
  pages        = "6--11",
  month        = jul,
  keywords     = "domestic portfolios, index funds, sector funds, country
    indexes, closed-end funds, dividends", 
  location     = "http://www.aaii.com/journal/article/exchange-traded-funds-a-new-twist-on-index-investing"
}

@Article{austhftesl,
  author       = "Ronald~E. Desautels and Mary Jo English",
  title        = "Are {U}.{S}. Treasuries Headed for the Endangered Species List?",
  journal      = "AAII Journal",
  year         = 2000,
  volume       = 22,
  number       = 6,
  pages        = "12--15",
  month        = jul,
  keywords     = "yield curve, debt reduction",
  location     = "http://www.aaii.com/journal/article/are-u-s-treasuries-headed-for-the-endangered-species-list-"
}

@Article{aladmostiop,
  author       = "John Bajkowski",
  title        = "{A} Look at Different Measures of Short-Term Influences on Prices",
  journal      = "AAII Journal",
  year         = 2000,
  volume       = 22,
  number       = 6,
  pages        = "25--28",
  month        = jul,
  keywords     = "tracking trades, the tick, money flow, block trades,
    overhang, short interest"
}

@Article{etetoiqm,
  author       = "Fayaz~A. Shaikh and Stan McClellan and Manpreet Singh and
    Sannedhi~K. Chakravarthy", 
  title        = "End-to-End Testing of {IP} {QoS} Mechanisms",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "80--87",
  month        = may,
  keywords     = "qos evaluation, network testbeds, voice transport",
  abstract     = "Despite IP-based communications' huge potential, the mass
    deployment of converged networks carryingdata, voice, and video has not
    progressedas projected.  These distributedsystems bring with them
    nontrivial complexitiesthat require rigorous performanceoptimization.Joint
    optimization of network charac-teristicsin the presence of general
    application-level traffic presents a complexchallenge.  Queuing strategies,
    call-admis-sioncontrols, congestion-avoidance mech-anisms,traffic-shaping
    policies, andpolicing technologies must each be optimized--often
    simultaneously--to provideadequate quality of service.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.999779"
}

@Article{dpsortt,
  author       = "Laura~E. Jackson and George~N. Rouskas",
  title        = "Deterministic Preemtive Scheduling of Real-Time Tasks",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "72--79",
  month        = may,
  keywords     = "wdm networks, slotted time, scheduling, deadlines",
  abstract     = "Scheduling problems are characterized by a system's
    processor types and tasks and the scheduling constraints imposed on them.
    For a given task set, a number of processors greater than or equal to one,
    and a set of constraints,scheduling must determine the existence of a
    feasible schedule and what algorithms can produce it.Many algorithms
    described in this survey can be applied directly in a network context.
    Existing multiprocessor scheduling algorithms do not address certain
    aspects of packet scheduling, however,and this research area will likely
    become essential in the future.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.999778"
}

@Article{nsfmep,
  author       = "T.~S. Raghu and R.~Ramesh and Andrew~B. Whinston",
  title        = "Next Steps for Mobile Entertainment Portals",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "63--70",
  month        = may,
  keywords     = "multiplayer games, argumentation-based design",
  abstract     = "Wireless games are constrained by the unpredictability and 
    length of player interactions, traffic volume, up time, and computational
    bottlenecks.They must also be reliable, scalable, and secure.  The authors
    describe an argumentation-based philosophy for analyzing game-content
    design that complements recent mobile-environment design efforts that use
    contextual inquiry and scenario-based validation techniques.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.999778"
}

@Article{ebpmtnbs,
  author       = "Selim Aissi and Pallavi Malu and Krishnamurthy Srinivasan",
  title        = "{E}-Business Process Modeling: The Next Big Step",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "55--62",
  month        = may,
  keywords     = "process coordination, web services",
  abstract     = "The Internet is emerging as the platform for automating both
    the provider and consumer ends of e-business transactions.  Businesses
    offer Web services--software components that use standard Internet
    technologies to interact dynamically with one another--to build bridges
    between systems.  The authors propose a Process Coordination Framework that
    provides the building blocks required for Web services enabled e-business
    automation.  PCF helps in understanding the roles of the various proposed
    standards with respect to these building blocks.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.999776"
}

@Article{tccbkef,
  author       = "Won Kim and Ki-Joon Chae and Dong-Sub Cho and Byoungju Choi
    and Anmo Jeong and Myung Kim and KiHo Lee and Meejeong Lee and Sang-Ho Lee
    and Seung-Soo Park and Hwan-Seung Yong",
  title        = "The {C}hamois Component-Based Knowledge Engineering Framework",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "46--54",
  month        = may,
  keywords     = "metadata management, fault injection, mutation analysis",
  abstract     = "The authors initiated the Chamois project to achieve two
    goals:  research major areas relevant to knowledge engineering and build a
    prototype knowledge engineering framework that incorporates many of their
    research results.  Chamois combines an infrastructure component that
    consists of software products and prototype modules and an application
    component that uses the infrastructure as a data and knowledge resource.",
  location     = ""
}

@Article{sdaosv,
  author       = "Kyle Eischen",
  title        = "Software Development: An Outsider's View",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "36--44",
  month        = may,
  keywords     = "rationalizing software, domain knowledge, software
    development", 
  abstract     = "Advocates of traditional software engineering and proponents
    of agile development appear no closer to a consensus now than they were 30
    years ago, when their debate began.  Yet how software is made is often a
    central concern in technical circles and in general social debates on
    privacy, trade, patents, and so on.  Building a bridge between the specific
    technical issues and the broader social concerns can thus help achieve a
    clearer understanding of software, making explicit its unique structures
    and important role in society.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.999774"
}

@Article{apfsv,
  author       = "Michael Blaha and Cheryl Smith",
  title        = "{A} Pattern for Softcoded Values",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 5,
  pages        = "28--34",
  month        = may,
  keywords     = "softcoded values, metadata, generalization, three-tiers",
  abstract     = "Builders of database applications focus on using data
    structure models to facilitate storing and retrieving data.  Using
    abstractions can enhance their understanding of these structures as well as
    their ability to subsequently manipulate data in the actual database
    application.  One such pattern the authors have repeatedly found useful
    nominally expresses soft coded values as a data model, but also involves
    object-oriented concepts and application-specific constraints and behavior.
    An equipment example describes an application of this pattern in
    industry.", 
  OPTlocation  = ""
}

@Article{titighsfi,
  author       = "Brad Zigler",
  title        = "Toiling in the Investment Garden:  Hedging Strategies for Investors",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 9,
  pages        = "10--14",
  month        = sep,
  keywords     = "stock index futures, stock index options, exchange-traded
    indices",
  location     = ""
}

@Article{isatbk,
  author       = "Brad Knowles",
  title        = "It's About Time",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "25--30",
  month        = oct,
  keywords     = "ntp, server pools, time synchronization",
  location     = "https://www.usenix.org/publications/login/october-2006-volume-31-number-5/its-about-time"
}

@Article{bnapdarc,
  author       = "Donald~L. Cassidy",
  title        = "Bad News and Price Disasters:  Avoiding, Responding, Coping",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 8,
  pages        = "12--15",
  month        = aug,
  keywords     = "stock management",
  abstract     = "Stock Selection Strategies: While FDA denials, post-merger 
    write-offs, product delays, and accounting frauds do drop stock prices
    harshly, the most frequent culprit is an earnings disappointment, the next
    most common is an earnings or growth warning.",
  location     = "http://www.aaii.com/journal/article/bad-news-and-price-disasters-avoiding-responding-coping"
}

@Article{evuper,
  author       = "John Bajkowski",
  title        = "Evaluating Valuations Using Price-Earnings Relatives",
  journal      = ieeec,
  year         = 2000,
  volume       = 22,
  number       = 9,
  pages        = "2--6",
  month        = oct,
  keywords     = "price-earnings relative, screens",
  abstract     = "Stock Screening: Price-earnings relatives can establish
    benchmark comparisons to help identify firms that have deviated from their
    normal valuation levels, assuming nothing has fundamentally changed in the
    company, industry or market.",
  location     = "http://www.aaii.com/journal/article/evaluating-valuations-using-price-earnings-relatives"
}

@Article{alahsbouc,
  author       = "Albert~J. Fredman",
  title        = "{A} Look at {HOLDRS}: Stock Bundles Offering Unique Characteristics",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 9,
  pages        = "7--11",
  month        = oct,
  keywords     = "holders, stock investing",
  abstract     = "Mutual Funds: Currently, most HOLDRS represent an 
    individual's undivided beneficial ownership in a basket of 20 of the
    largest, most liquid companies in an industry.  Unlike mutual funds, you
    have more control because you actually own each stock.", 
  location     = "http://www.aaii.com/journal/article/a-look-at-holdrs-stock-bundles-offering-unique-characteristics"
}

@Article{tifwsmtcs,
  author       = "Marcus~W. Robins",
  title        = "The Idiot Factor: Who's Minding the Corporate Store?",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 9,
  pages        = "12--15",
  month        = oct,
  keywords     = "kruger-dunning errors, conformation bias, management",
  abstract     = "Stock Selection Strategies: Is it possible the CEO of your
    favorite investment is a dolt and blissfully unaware of it? A look at how
    it can happen, and how to evaluate the competence of corporate managers.",
  location     = "http://www.aaii.com/journal/article/the-idiot-factor-who-s-minding-the-corporate-store-"
}

@Article{htbyopfm,
  author       = "James O'Shaugnessy",
  title        = "How to Be Your Own Personal Fund Manager",
  journal      = aaiij,
  year         = 2000,
  volume       = 22,
  number       = 9,
  pages        = "18--20",
  month        = oct,
  keywords     = "portfolio management, planning",
  abstract     = "Portfolio Strategies: Until recently, high minimum
    commissions and limited access to information were high hurdles for small
    investors who wanted to build diversified stock portfolios.  The Internet
    has changed that.",
  location     = "http://www.aaii.com/journal/article/how-to-be-your-own-personal-fund-manager"
}

@Article{srtbysip,
  author       = "William~J. O'Neil",
  title        = "Sell Rules to Build Your Stock Investing Performance",
  journal      = aaiij,
  year         = 2000,
  volume       = 21,
  number       = 8,
  pages        = "2--5",
  month        = sep,
  keywords     = "loss cutting, profit taking, sell indicators, the market",
  abstract     = "Stock Strategies: For many investors, selling is their
    greatest weakness.  Spend time learning from your mistakes, and
    consistently use sell rules that keep the emotion and ego out of
    investing.",
  location     = "http://www.aaii.com/journal/article/sell-rules-to-build-your-stock-investing-performance"
}

@Article{uifaapoyaas,
  author       = "Albert~J. Fredman",
  title        = "Using Index Funds as a Part of Your Asset Allocation Strategy",
  journal      = aaiij,
  year         = 2000,
  volume       = 21,
  number       = 7,
  pages        = "8--13",
  month        = jul,
  keywords     = "growth, value, size, international indexes, bond indexes",
  abstract     = "Mutual Funds: Consistency of style, low costs, the assurance
    of besting most active managers, and tax efficiency are compelling reasons
    to give index funds a high priority in your asset allocation strategy.",
  location     = "http://www.aaii.com/journal/article/using-index-funds-as-a-part-of-your-asset-allocation-strategy"
}

@Article{fsaalatis,
  author       = "John Bajkowski",
  title        = "Financial Statement Analysis: {A} Look at the Income Sheet",
  journal      = aaiij,
  year         = 1999,
  volume       = 21,
  number       = 4,
  pages        = "23--26",
  month        = apr,
  keywords     = "income statement, accrual accounting, operating expenses,
    income tax, income adjustments, net income",
  abstract     = "Fundamentals: The goal of the income statement is to 
    determine revenue for the period covered and then match the corresponding
    expenses to the revenue.  It presents a picture of a company's
    profitability over the entire period of time covered.", 
  location     = "http://www.aaii.com/journal/article/financial-statement-analysis-a-look-at-the-income-sheet"
}

@Article{mcmah,
  author       = "Richard McDougall and James Laudon",
  title        = "Multi-Core Microprocessors Are Here",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "32--39",
  month        = oct,
  keywords     = "multicore, processor architectures, multi-threading",
  location     = "https://www.usenix.org/publications/login/october-2006-volume-31-number-5/multi-core-microprocessors-are-here"
}

@Article{itnip,
  author       = "Jason~G. Andress",
  title        = "{IPv6}: The Next {I}nternet Protocol",
  journal      = login,
  year         = 2005,
  volume       = 30,
  number       = 2,
  pages        = "21--28",
  month        = apr,
  keywords     = "ipv4, ipv6, headers, routing, configuration, security, qos,
    deployment",
  location     = "https://www.usenix.org/publications/login/april-2005-volume-30-number-2/ipv6-next-internet-protocol"
}

@Article{fsaalatbs,
  author       = "John Bajkowski",
  title        = "Financial Statement Analysis:  {A} Look at the Balance Sheet",
  journal      = aaiij,
  year         = 1999,
  volume       = 21,
  number       = 1,
  pages        = "7--10",
  abstract     = "Fundamentals: The items in financial statements help measure
    the performance of a company and its management as well as help investors
    gauge the worth of the stock price. A look at balance sheet items.",
  month        = jan,
  keywords     = "balance sheet, current assets, goodwill, current liabilities,
    long-term liabilities, stockholder's equity",
  location     = "http://www.aaii.com/journal/article/financial-statement-analysis-a-look-at-the-balance-sheet"
}

@Article{mpofde,
  author       = "Timo Sivonen",
  title        = "Measuring Performance of {FreeBSD} Disk Encryption",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 5,
  pages        = "40--45",
  month        = oct,
  keywords     = "performance, disk encryption, freebsd",
  location     = "https://www.usenix.org/publications/login/october-2006-volume-31-number-5/measuring-performance-freebsd-disk-encryption"
}

@Article{alatccfs,
  author       = "John Bajkowski",
  title        = "{A} Look at the Coporate Cash Flow Statement",
  journal      = aaiij,
  year         = 1999,
  volume       = 21,
  number       = 6,
  pages        = "26--29",
  month        = jun,
  keywords     = "cash flows, currency translation, net cash change",
  abstract     = "Fundamentals: The cash flow statement can give valuable
    insight into how well a company is managing its growth. Ultimately, firms
    have to produce cash to do well in the long run.",
  location     = "http://www.aaii.com/journal/article/a-look-at-the-corporate-cash-flow-statement"
}

@Article{wsdosm,
  author       = "Andrey Mirtchovski and Latchesar Ionkov",
  title        = "Why Some Dead {OSes} Still Matter",
  journal      = login,
  year         = 2007,
  volume       = 32,
  number       = 5,
  pages        = "5--12",
  month        = oct,
  keywords     = "plan 9, simplicity, generality, clarity, ",
  location     = "https://www.usenix.org/publications/login/october-2007-volume-32-number-5/why-some-dead-oses-still-matter"
}

@Article{dbacehshsfs,
  author       = "Mark Uris",
  title        = "{DataMonster}:  Building a Cost-Effective, High-Speed, Heterogeneous Shared File System",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "7--14",
  month        = aug,
  keywords     = "storage devices, file systems, raid",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/datamonster-building-cost-effective-high-speed"
}

@Article{imi,
  author       = "Darrell Fuhriman",
  title        = "Identity Management Identified",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "21--25",
  month        = aug,
  keywords     = "identify management",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/identity-management-identified"
}

@Article{saocacs,
  author       = "Andy Seely",
  title        = "System Administration of Command and Control Systems",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "26--31",
  month        = aug,
  keywords     = "mission orientation, critical support issues, government off
    the shelf",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/system-administration-command-and-control-systems"
}

@Article{caslfts,
  author       = "KyoungSoo Park and Vivek~S. Pai",
  title        = "{CoBlitz}: {A} Scalable Large-File Transfer Service",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "32--37",
  month        = aug,
  keywords     = "proxies, bit torrent",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/coblitz-scalable-large-file-transfer-service"
}

@Article{apatptpps,
  author       = "Ryan Peterson and Venugopalan Ramasubramanian and Emin G{\" u}n Sirer",
  title        = "{A} Practical Approach to Peer-to-Peer Publish-Subscribe",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "38--4",
  month        = aug,
  keywords     = "corona, ",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/practical-approach-peer-peer-publish-subscribe"
}

@Article{ersulaost,
  author       = "Eric Sorenson",
  title        = "Enterprise Routing Sinkholes Using {L}inux and Open Source Tools",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "43--48",
  month        = aug,
  keywords     = "architectural overview, routing implementation, ",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/enterprise-routing-sinkholes-using-linux-and-open"
}

@Article{tphph,
  author       = "Pete Herzog",
  title        = "The Protocol Historian",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 4,
  pages        = "49--55",
  month        = aug,
  keywords     = "network protocols",
  location     = "https://www.usenix.org/publications/login/august-2006-volume-31-number-4/protocol-historian"
}

@Article{agtiireit,
  author       = "Michael Grupe and Charles DiRocco",
  title        = "{A} Guide to Investing in Real Estate Investment Trusts",
  journal      = aaiij,
  year         = 2000,
  volume       = 31,
  number       = 4,
  pages        = "9--14",
  month        = nov,
  keywords     = "performance, diversification, reits, dividends,
    price-earnings multiples, net asset values, ",
  abstract     = "Stock Selection Strategies: Improving stability in the real
    estate market, compelling market values, and the search for less volatile
    investments in a turbulent market environment all prompt investors to give
    REITs a second look.",
  location     = "http://www.aaii.com/journal/article/a-guide-to-investing-in-real-estate-investment-trusts"
}

@Article{wtlfiaps,
  author       = "Tom Burnett",
  title        = "What To Look For In {A} Proxy Statement",
  journal      = aaiij,
  year         = 2001,
  volume       = 22,
  number       = 2,
  pages        = "8--11",
  month        = feb,
  keywords     = "proxy statements, edgar, executive compensation,
    transactions",
  abstract     = "Stock Selection Strategies: All publicly traded companies
    must file a proxy statement once a year in advance of their annual
    meeting. These statements can contain a wealth of critical data about a
    firm's financial health if you know where to look.",
  location     = "http://www.aaii.com/journal/article/the-key-points-to-look-for-in-a-corporate-proxy-statement"
}

@Article{iibhtrtpt,
  author       = "Bond Market Association",
  title        = "Investing in Bonds: How to Read the Price Tables",
  journal      = aaiij,
  year         = 2001,
  volume       = 22,
  number       = 2,
  pages        = "12--14",
  month        = feb,
  keywords     = "bond tables, tax exemption, coporates",
  abstract     = "Bonds: With millions of bonds outstanding, newspaper listings
    don't cover every single issue. But only a small fraction of outstanding
    bonds trade on any day, so listings of representative prices provides
    investors with sufficient benchmark information.",
  location     = "http://www.aaii.com/journal/article/investing-in-bonds-how-to-read-the-price-tables"
}

@Article{tvhiarcsm,
  author       = "Mark Hulbert",
  title        = "Trading Versus Holding in a Roller-Coaster Stock Market",
  journal      = aaiij,
  year         = 2001,
  volume       = 22,
  number       = 2,
  pages        = "30--33",
  month        = feb,
  keywords     = "performance measurements, buy and hold",
  abstract     = "Investment Newsletters: An examination of trading performance
    indicates that you can better capture the value of an investment
    newsletter's advice by ignoring its shorter-term trades and treating its
    current recommendations as longer-term advice.",
  location     = "http://www.aaii.com/journal/article/trading-versus-holding-in-a-roller-coaster-stock-market"
}

@Article{pstbwuroe,
  author       = "Timothy Vick",
  title        = "Picking Stocks the Buffett Way: Understanding Return on Equity",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 3,
  pages        = "4--7",
  month        = apr,
  keywords     = "roe calculations, performance predictions",
  abstract     = {Stock Selection Strategies: "The primary test of managerial
    economic performance is the achievement of a high earnings rate on equity
    capital employed ..." [From the 1979 Berkshire Hathaway annual report].},
  location     = "http://www.aaii.com/journal/article/picking-stocks-the-buffett-way-understanding-return-on-equity"
}

@Article{tvovfwysaht,
  author       = "John Markese",
  title        = "The Value of Value Funds: Why You Should Always Hold Them",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 3,
  pages        = "8--10",
  month        = apr,
  keywords     = "value, returns, benchmarks",
  abstract     = "Mutual Funds: Over long-term periods, value and growth stocks
    run nearly neck-to-neck in terms of performance, but the returns from value
    stocks are more stable, and they tend to perform better than growth during
    down markets.", 
  location     = "http://www.aaii.com/journal/article/the-value-of-value-funds-why-you-should-always-hold-them"
}

@Article{aisgtaetf,
  author       = "Albert~J. Fredman",
  title        = "An Investor's Guide to Analyzing Exchange-Traded Funds",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 4,
  pages        = "8--13",
  month        = may,
  keywords     = "index trackers, tracking error, distributions, portfolios,
  pricing, data mismatches, arbitrages, liquidity, trading",
  abstract     = "Mutual Funds: Tradable funds require greater investor
    sophistication than ordinary mutual funds because they trade like a
    stock. The stock dimension may also ignite latent speculative tendencies
    that might otherwise lie dormant.", 
  location     = "http://www.aaii.com/journal/article/an-investor-s-guide-to-analyzing-exchange-traded-funds"
}

@Article{wtsaspapr,
  author       = "Donald Cassidy",
  title        = "When to Sell a Stock: Practical and Profitable Rules",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 4,
  pages        = "4--7",
  month        = may,
  keywords     = "selling rules, short-term tactics",
  abstract     = "Stock Selection Strategies: Many investors feel the odds are
    against them if they sell. The mutual fund industry drums the buy and hold
    refrain; but growth funds have holding periods of slightly under a
    year. Rules for selling stock.", 
  location     = "http://www.aaii.com/journal/article/when-to-sell-a-stock-practical-and-profitable-rules"
}

@Article{falitrs,
  author       = "Joe Abley",
  title        = "Fear and Loathing in the Routing System",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "5--11",
  month        = feb,
  keywords     = "anycast, tcp",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/fear-and-loathing-routing-system"
}

@Article{fx1tsx1wdcmm,
  author       = "Alva Couch",
  title        = "From {x = 1} to ({setf x 1}): What Does Configuration Management Mean?",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "12--18",
  month        = feb,
  keywords     = "semantics, configuration management, abstraction, modeling",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/x1-setf-x-1-what-does-configuration-management"
}

@Article{hbtdbs,
  author       = "Eric Langheinrich",
  title        = "http:{BL}: Taking {DNSBL} Beyond {SMTP}",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "19--24",
  month        = feb,
  keywords     = "mail",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/httpbl-taking-dnsbl-beyond-smtp"
}

@Article{cpmus,
  author       = "Justin Samuel and Jeremy Plichta and Justin Cappos",
  title        = "Centralized Package Management Using {S}tork",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "25--31",
  month        = feb,
  keywords     = "software management",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/centralized-package-management-using-stork"
}

@Article{mdawp,
  author       = "Jeannie Albrecht and Ryan Braud and Ren Dao and Nikolay
  Topilski and Christopher Tuttle and Alex~C. Snoeren and and Amin Vahdat",
  title        = "Managing Distributed Applications with {P}lush",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "32--",
  month        = feb,
  keywords     = "distributed applications, configuration, monitoring, resource
    management, performance evaluation",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/managing-distributed-applications-plush"
}

@Article{aitld,
  author       = "Octave Oregeron",
  title        = "An Introduction to Logical Domains",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "39--47",
  month        = feb,
  keywords     = "solaris, logical domains, networking, storage",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/introduction-logical-domains"
}

@Article{iidxs,
  author       = "Aditya~K Sood",
  title        = "Insecurities in Designing {XML} Signatures",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "48--53",
  month        = feb,
  keywords     = "digital signatures, xml, parsing, error checks, validation",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/insecurities-designing-xml-signatures"
}

@Article{iptp,
  author       = "David Josephsen",
  title        = "{iVoyeur}: Permission to Parse",
  journal      = login,
  year         = 2008,
  volume       = 33,
  number       = 1,
  pages        = "65--71",
  month        = feb,
  keywords     = "http, burp",
  location     = "https://www.usenix.org/publications/login/february-2008-volume-33-number-1/ivoyeur-permission-parse"
}

@Article{ggasfwawtcf,
  author       = "John Markese",
  title        = "Going Global: {A} Single Fund With a World to Choose From",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 5,
  pages        = "4--6",
  month        = jun,
  keywords     = "global funds, risk, diversity",
  abstract     = "Mutual Funds: International diversification does not have the
    pronounced benefits it once had. But while world stock markets occasionally
    all do the same short-term dance, they still do not move in unison over the
    long term.",
  location     = "http://www.aaii.com/journal/article/going-global-a-single-fund-with-a-world-to-choose-from"
}

@Article{bbfiagtbas,
  author       = "AAII Staff",
  title        = "Bond Basics for Individuals: {A} Guide to Buying and Selling",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 5,
  pages        = "37--42",
  month        = jun,
  keywords     = "bond market, pricing, commissions, brokers",
  abstract     = "In the bond markets, individual investors--even the
    wealthy--are all little guys.  To protect your own interests, if you want
    to buy individual bonds you need to become an informed investor.",
  location     = "http://www.aaii.com/journal/article/bond-basics-for-individuals-a-guide-to-buying-and-selling"
}

@Article{htkwtlgwyastl,
  author       = "Mark Hulbert",
  title        = "How to Know When to Let Go When Your Advisor Starts to Lag",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 5,
  pages        = "46--48",
  month        = jun,
  keywords     = "contingency plans, analysis, ",
  abstract     = "Investment Newsletters: Most investors have no contingency
    plan for how to react if their chosen advisor doesn't perform as
    hoped. It's difficult to analyze your portfolio dispassionately and
    objectively once you have lost a lot of money.", 
  location     = "http://www.aaii.com/journal/article/how-to-know-when-to-let-go-when-your-advisor-starts-to-lag"
}

@Article{urtaswyntka,
  author       = "Ellis Traub",
  title        = "Using {ROE} to Analyze Stocks: What You Need to Know About",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 6,
  pages        = "4--7",
  month        = jul,
  keywords     = "return on equity, evaluation",
  abstract     = "Stock Fundamentals: For evaluating management's skill at
    making use of a company's equity, ROE is the preferred metric. However, it
    must mean precisely the same thing to everyone who uses it.",
  location     = "http://www.aaii.com/journal/article/using-roe-to-analyze-stocks-what-you-need-to-know-about"
}

@Article{sumfrlcai,
  author       = "Albert J. Fredman",
  title        = "Sizing Up Mutual Fund Relatives: Low-Cost Alternative Investing",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 6,
  pages        = "9--14",
  month        = jul,
  keywords     = "compounding, variable annuities, closed-end funds, holders,
    custom portfolios",
  abstract     = "Mutual Funds: ETFs, closed-end funds, HOLDRS, and folios
    require greater investment sophistication, but may offer unique advantages
    for savvy investors. Costs, investment control and tax efficiency play a
    major role in evaluating the alternatives.",
  location     = "http://www.aaii.com/journal/article/sizing-up-mutual-fund-relatives-low-cost-alternative-investing"
}

@Article{tsmtnyfsc,
  author       = "Marcus~W. Robins",
  title        = "The Stock Market Today: Not Your Father's Correction",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 6,
  pages        = "29--31",
  month        = jul,
  keywords     = "corrections, stocks",
  abstract     = "Stock Selection Strategies: Although there are some
    interesting parallels, things are considerably different today compared to
    what they were in the early 1970s.",
  location     = "http://www.aaii.com/journal/article/the-stock-market-today-not-your-father-s-correction"
}

@Article{mpdf,
  author       = "Doug Farrell",
  title        = "Mediator\slash {P}ython",
  journal      = lj,
  year         = 2002,
  number       = 98,
  pages        = "60--62",
  month        = jun,
  keywords     = "software patterns, python,",
  location     = "http://www.linuxjournal.com/article/5858"
}

@Article{oamd,
  author       = "Richard~S. {Wright Jr.}",
  title        = "{OpenGL} and Mobile Devices",
  journal      = ddj,
  year         = 2006,
  number       = 385,
  pages        = "30--35",
  month        = jun,
  keywords     = "egl, graphics libraries, gizmondo",
  abstract     = "OpenGL is the de facto standard for cross-platform real-time
    3D graphics. OpenGL ES extends these capabilities to mobile devices.",
  location     = "http://www.drdobbs.com/mobile/187203532"
}

@Article{htrmb,
  author       = "Mikael Baros",
  title        = "Heightmap Terrain Rendering",
  journal      = ddj,
  year         = 2006,
  number       = 385,
  pages        = "51--54",
  month        = jun,
  keywords     = "quads, landscape mode, rendering",
  abstract     = "Using heightmaps and Java's Mobile 3D Graphics API to create
    realistic 3D graphics for mobile devices.",
  location     = "http://www.drdobbs.com/jvm/187203544"
}

@Article{smbmjh,
  author       = "Mark~J. Himelstein",
  title        = "Software Management Basics",
  journal      = ddj,
  year         = 2006,
  number       = 385,
  pages        = "62--65",
  month        = jun,
  keywords     = "execution, communication, empowerment",
  abstract     = "Most software managers didn't start out as managers, but
    began their careers as developers.",
  location     = "http://www.drdobbs.com/architecture-and-design/187203587"
}

@Article{itdd,
  author       = "Rick Grehan",
  title        = "Inside the {db4o} Database",
  journal      = ddj,
  year         = 2006,
  number       = 385,
  pages        = "66--69",
  month        = jun,
  keywords     = "acid, replication",
  abstract     = "Among other features, db4o, an open-source object database
    for Java and .NET, has built-in support for synchronization.",
  location     = "http://www.drdobbs.com/database/187203597"
}

@Article{scicc,
  author       = "Robert~C. Seacord",
  title        = "Secure Coding In " # cpp # "\slash {CLI}",
  journal      = ddj,
  year         = 2006,
  number       = 385,
  pages        = "70--76",
  month        = jun,
  keywords     = "buffer overflow, secure programming",
  abstract     = "C++/CLI is an extension to C++ that adds properties, events,
    garbage collection, and generics for all types including existing Standard
    C++ classes.",
  location     = "http://www.drdobbs.com/security/187203693"
}

@Article{lbtr,
  author       = "Pete Becker",
  title        = "Living By the Rules",
  journal      = ddj,
  year         = 2006,
  number       = 385,
  pages        = "77--84",
  month        = jun,
  keywords     = "grammars, diagnostics",
  abstract     = "Understanding compiler rules better equips you to interpret
    messages the compiler sends you.",
  location     = "http://www.drdobbs.com/cpp/187203727"
}

@Article{ddsmyahsw,
  author       = "Donald Cassidy",
  title        = "Do Dividends Still Matter? {Y}es---And Here's Why",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 7,
  pages        = "4--8",
  month        = aug,
  keywords     = "dividends",
  abstract     = "Stock Selection Strategies: Even in the extraordinary market
    climate of the past several years, dividend actions have been strong
    predictors of stock-price action. Dividend yields also provide a cushion
    under prices when stocks go through sinking spells.",
  location     = "http://www.aaii.com/journal/article/do-dividends-still-matter-yes-151-and-here-s-why"
}

@Article{fcufoymfp,
  author       = "John Markese",
  title        = "Financial Check-Up: Figuring Out Your Mutual Fund Portfolio",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 7,
  pages        = "9--12",
  month        = aug,
  keywords     = "risk, portfolio management",
  abstract     = "Mutual Funds: A simple worksheet for your mutual fund
  portfolio allows you to see what it may generate over time in terms of
  income, return, and risk. It also allows you to see the trade-offs that can
  occur with different allocations.",
  location     = "http://www.aaii.com/journal/article/2-financial-check-up-figuring-out-your-mutual-fund-portfolio"
}

@Article{ftwalptbvs,
  author       = "John Bajkowski",
  title        = "Finding the Winners Among Low Price-to-Book-Value Stocks",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 7,
  pages        = "13--16",
  month        = aug,
  keywords     = "stock selection, value screens",
  abstract     = "Stock Screening: Simple value screens that look only for low
    prices relative to value tend to produce lists that include a few winners
    among many losers. One promising new system seeks low-valued stocks that
    also have solid financials.",
  location     = "http://www.aaii.com/journal/article/finding-the-winners-among-low-price-to-book-value-stocks"
}

@Article{otm,
  author       = "Tom Haynes",
  title        = "{OpenSolaris}: The Model",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "5--8",
  month        = apr,
  keywords     = "open source, solaris",
  abstract     = "",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/opensolaris-model"
}

@Article{ctairit,
  author       = "Brian Kernighan",
  title        = "Code Testing and Its Role in Teaching",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "9--18",
  month        = apr,
  keywords     = "testing, awk, test automation, little languages, test data,
    teaching",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/code-testing-and-its-role-teaching"
}

@Article{mspim3,
  author       = "Jorrit~N. Herder and Herbert Bos and Ben Gras and Philip
    Homburg and Andrew~S Tanenbaum",
  title        = "Modular System Programming in {MINIX} 3",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "19--28",
  month        = apr,
  keywords     = "reliability, layering, microkernels, user-space development",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/modular-system-programming-minix-3"
}

@Article{stomameto,
  author       = "Diomedis Spinellis",
  title        = "Some Types of Memory Are More Equal than Others",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "29--36",
  month        = apr,
  keywords     = "primary store, cache, performance, banked storage, swap",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/some-types-memory-are-more-equal-others"
}

@Article{ssfaugc,
  author       = "Chaos Golubitsky",
  title        = "Simple Software Flow Analysis Using {GNU} {Cflow}",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "37--41",
  month        = apr,
  keywords     = "call graphs, cflow, cross-references",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/simple-software-flow-analysis-using-gnu-cflow"
}

@Article{uhwhtt,
  author       = "David Malone",
  title        = "Unwanted {HTTP}: Who Has the Time?",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "49--54",
  month        = apr,
  keywords     = "misconfiguration, ntp, system administration, problem
    tracking", 
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/unwanted-http-who-has-time"
}

@Article{asurl,
  author       = "Randolph Langley",
  title        = "Auditing Superuser Usage",
  journal      = login,
  year         = 2005,
  volume       = 31,
  number       = 2,
  pages        = "56--59",
  month        = apr,
  keywords     = "system administration, root",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/auditing-superuser-usage"
}

@Article{wysur,
  author       = "Luke Kanies",
  title        = "Why You Should Use {Ruby}",
  journal      = login,
  year         = 2006,
  volume       = 31,
  number       = 2,
  pages        = "42--48",
  month        = apr,
  keywords     = "objects, operators, introspection, iteration, blocks",
  location     = "https://www.usenix.org/publications/login/april-2006-volume-31-number-2/why-you-should-use-ruby"
}

@Article{smviiet,
  author       = "Michael Kassen",
  title        = "Surviving Market Volatility:  Investing in Extraordinary Times",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 8,
  pages        = "9--10",
  month        = sep,
  keywords     = "volatility, diversification",
  abstract     = "Market Structure: In mid-2001, volatility as measured by
    standard deviation of monthly returns for the S&P 500 is only a hair above
    average, and not as high as during the bear market of the mid-1970s or the
    crash of 1987.", 
  location     = "http://www.aaii.com/journal/article/surviving-market-volatility-investing-in-extraordinary-times"
}

@Article{oaasgfi,
  author       = "Mark Hulbert",
  title        = "Outrageous Advertising: {A} Survival Guide for Investors",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 8,
  pages        = "52--54",
  month        = sep,
  keywords     = "backtesting, lies by any other name, time shifting",
  abstract     = "Investment Newsletters: You wouldn't believe a used car
    salesman who claimed that an old car had only been driven to church on
    Sundays. Yet many investors paid good money to a newsletter that claimed it
    turned $10,000 into over $40 million in 13 years.",
  location     = "http://www.aaii.com/journal/article/2-outrageous-advertising-a-survival-guide-for-investors"
}

@Article{usgbfapc,
  author       = "John Markese",
  title        = "{U}.{S}. Government Bond Funds:  {A} Portfolio Counterweight",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 10,
  pages        = "4--6",
  month        = nov,
  keywords     = "risks, us treasuries",
  abstract     = "Mutual Funds: As a relatively low risk, understandable and
    steady counterweight for your stock portfolio, U.S. government bond funds
    are hard to beat if you do not want to buy the bonds directly and manage
    them yourself.", 
  location     = "http://www.aaii.com/journal/article/u-s-government-bond-funds-a-portfolio-counterweight"
}

@Article{bibwbpguad,
  author       = "Annette Thau",
  title        = "Bond Investing Basics: Why Bond Prices Go Up and Down",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 10,
  pages        = "7--12",
  month        = nov,
  keywords     = "interest rate, risk, risk management, credit ratings,
  valuation, ratings",
  abstract     = "Bonds: Since the late 1970s, changes in the interest rate
    environment have become the greatest single determinant of bond returns,
    and managing interest rate risk has become the most critical variable in
    the management of bond portfolios.", 
  location     = "http://www.aaii.com/journal/article/bond-investing-basics-why-bond-prices-go-up-and-down"
}

@Article{wsystwysspf,
  author       = "Wayne~A. Thorp",
  title        = "What Steps You Should Take When Your Stock's Price Falls",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 10,
  pages        = "20--24",
  month        = nov,
  keywords     = "market weaknesses, industry cycles, regulatory changes,
    competitors, ",
  abstract     = "Stock Selection Strategies: There are no simple rules that
    will tell you when to sell a stock, but an in-depth understanding of what
    economic, industry, and firm fundamentals drive the price will better equip
    you for making decisions.",
  location     = "http://www.aaii.com/journal/article/what-steps-you-should-take-when-your-stock-s-price-falls"
}

@Article{wmtbtbrf,
  author       = "James~B. Cloonan",
  title        = "When Markets Turn Bad the Basics Remain Fundamental",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 10,
  pages        = 28,
  month        = nov,
  keywords     = "diversification, risk",
  abstract     = "Feature: The year 2001 has been an example of the need for
    diversification across styles as well as industries. And the entire bear
    market should emphasize the need for a long-term commitment.",
  location     = "http://www.aaii.com/journal/article/when-markets-turn-bad-the-basics-remain-fundamental"
}

@Article{wtlfiacembf,
  author       = "Albert~J. Fredman",
  title        = "What to Look for in a Closed-End Municipal Bond Fund",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 1,
  pages        = "3--8",
  month        = jan,
  keywords     = "discounts, leverage, short rates, long rates, performance,
    interest rates risk, dividend, income",
  abstract     = "Mutual Funds: A closed-end fund's stock price can rise above
    or fall below its net asset value, depending upon supply and demand. While
    bond fund markdowns don't get as deep as those on equity funds, you can
    still find opportunities.",
  location     = "http://www.aaii.com/journal/article/what-to-look-for-in-a-closed-end-municipal-bond-fund"
}

@Article{bbaisgttmmoy,
  author       = "Annette Thau",
  title        = "Bond Basics: An Investor's Guide to the Many Meanings of Yield",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 1,
  pages        = "24--27",
  month        = jan,
  keywords     = "yield, simple interest, coupon yield, current yield, yield to
    maturity, coupons, total return",
  abstract     = {Bond Basics: An Investor´s Guide to the Many Meanings of
    Yield Bonds: The term "yield" can be confusing to investors because it has
    a number of different meanings. Even more confusing is the fact that these
    meanings are not directly comparable for individual bonds and for bond
    funds.},
  location     = "http://www.aaii.com/journal/article/bond-basics-an-investor-s-guide-to-the-many-meanings-of-yield"
}

@Article{ptitmotfdi,
  author       = "Mark Hulbert",
  title        = "Predicting The Index:  The Myth of the Five-Day Index",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 2,
  pages        = "34--35",
  month        = feb,
  keywords     = "predictions",
  abstract     = "Many advisers subscribe to the belief that if the first five
    trading days of the year produce a gain, the year as a whole will be
    bullish, too. But is it grounded in historical fact? How certain beliefs
    take on a life of their own.",
  location     = "http://www.aaii.com/journal/article/predicting-market-directions-the-myth-of-the-five-day-index"
}

@Article{eronoiwc,
  author       = "Hyokyung Bahn and Kern Koh and Sang Lyul Min and Sam~H. Noh",
  title        = "Efficient Replacement of Nonuniform Objects in Web Caches",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 2,
  pages        = "65--73",
  month        = jun,
  keywords     = "object caching, replacement algorithms, web proxies",
  abstract     = "Cache performance depends heavily on replacement algorithms,
    which dynamically select a suitable subset of objects for caching in a
    finite space.  Developing such algorithms for wide-area distributed
    environments is challenging because, unlike traditional paging systems,
    retrieval costs and object sizes are not necessarily uniform.  In a uniform
    caching environment, a replacement algorithm generally seeks to reduce
    cache misses, usually by replacing an object with the least likelihood of
    re-reference.  In contrast, reducing total cost incurred due to cache
    misses is more important in nonuniform caching environments.  The authors
    present the least-unified value algorithm, which performs better than
    existing algorithms for replacing nonuniform data objects in wide-area
    distributed environments"
}

@Article{yasgcms,
  author       = "Cyrus Shahabi and Roger Zimmermann and Kun Fu and Shu-Yuen
    Didi Yao", 
  title        = "Yima: {A} Second-Generation Continuous Media Server",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 6,
  pages        = "56--64",
  month        = jun,
  keywords     = "media server, data reorganization, multistream
    synchronization", 
  abstract     = "Continuous media data requires a streaming architecture that
    can manage real-time delivery constraints and address the large size of CM
    objects.  Although commercial systems ordinarily use proprietary technology
    and algorithms, making it difficult to compare their products with research
    prototypes, the authors have designed and developed Yima, a
    second-generation CM server that demonstrates several advanced concepts.
    Although this system has not yet achieved the refinement of commercial
    solutions, it is operational and incorporates lessons learned from
    first-generation research prototypes, including complete distribution,
    efficient online scalability, and synchronization of several media streams
    within a single frame.  The paper discusses the multinode server
    architecture", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1009169"
}

@Article{stfhpna,
  author       = "William T.~C. Kramer",
  title        = "{SCinet}: Testbed for High-Performance Networked Applications",
  journal      = ieeec,
  year         = 2006,
  volume       = 35,
  number       = 6,
  pages        = "47--55",
  month        = jun,
  keywords     = "remote visualization, bandwidth, qos",
  abstract     = "The network's use by high-performance applications is 
    difficult to evaluate in the real world.  To better understand this
    interaction, leading experts and organizations in ultra-high-performance
    networking and computing come together once a year to build an intense,
    diverse, high-performance network.  Almost overnight, the SCinet network
    comes online as a testbed to show-case state-of-the-art network technology
    at the IEEE/ACM-sponsored supercomputing conference known as SCxy.  in the
    words of one network engineer, the SCinet team challenges application
    developers to burn down the world's fastest network. They selected 10 of
    the most data-intensive applications in 2000 and 12 applications in 2001
    for evaluation in a formal judging", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1009168"
}

@Article{gsfdsi,
  author       = "Ian Foster and Carl Kesselman and Jeffrey~M. Nick  Steven
    Tuecke", 
  title        = "Grid Services for Distributed System Integration",
  journal      = ieeec,
  year         = 2006,
  volume       = 35,
  number       = 6,
  pages        = "37--46",
  month        = jun,
  keywords     = "globus, grids, open grids, ",
  abstract     = "Increasingly, computing addresses collaboration, data
    sharing, and interaction modes that involve distributed resources,
    resulting in an increased focus on the interconnection of systems both
    within and across enterprises.  These evolutionary pressures have led to
    the development of Grid technologies.  The authors' work focuses on the
    nature of the services that respond to protocol messages.  Grid provides an
    extensible set of services that can be aggregated in various ways to meet
    the needs of virtual organizations, which themselves can be defined in part
    by the services they operate and share",
  location     = "http://dx.doi.org/10.1109/MC.2002.1009167"
}

@Article{sdtetcui,
  author       = "Michael~F. McTear",
  title        = "Spoken Dialogue Technology: Enabling the Conversational User Interface",
  journal      = surveys,
  year         = 2002,
  volume       = 34,
  number       = 1,
  pages        = "90--169",
  month        = mar,
  keywords     = "dialog management, human computer interaction, language
    generation, language understanding, speech recognition, speech synthesis,
    human factors",
  abstract     = "Spoken dialogue systems allow users to interact with
    computer-based applications such as databases and expert systems by using
    natural spoken language.  The origins of spoken dialogue systems can be
    traced back to Artificial Intelligence research in the 1950s concerned with
    developing conversational interfaces.  However, it is only within the last
    decade or so, with major advances in speech technology, that large-scale
    working systems have been developed and, in some cases, introduced into
    commercial environments.  As a result many major telecommunications and
    software companies have become aware of the potential for spoken dialogue
    technology to provide solutions in newly developing areas such as
    computer-telephony integration.  Voice portals, which provide a
    speech-based interface between a telephone user and Web-based services, are
    the most recent application of spoken dialogue technology.  This article
    describes the main components of the technology---speech recognition,
    language understanding, dialogue management, communication with an external
    source such as a database, language generation, speech synthesis---and
    shows how these component technologies can be integrated into a spoken
    dialogue system.  The article describes in detail the methods that have
    been adopted in some well-known dialogue systems, explores different system
    architectures, considers issues of specification, design, and evaluation,
    reviews some currently available dialogue development toolkits, and
    outlines prospects for future development.",
  location     = "http://dx.doi.org/10.1145/505282.505285"
}

@Article{htramfptss,
  author       = "John Mankese",
  title        = "How To Rate A Mutual Fund:  Personalizing the Star System",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 3,
  pages        = "4--7",
  month        = apr,
  keywords     = "fund ratings, fund comparisons",
  abstract     = {Mutual Funds: The funds that made it into AAII's Top Funds
    Guide are of investor interest and are readily available, with low expenses
    and no or low loads, above-average returns, and they have not "bought"
    their returns with mountainous risk.},
  location     = "http://www.aaii.com/journal/article/how-to-rate-a-mutual-fund-personalizing-the-star-system"
}

@Article{iiustattdp,
  author       = "Annette Thau",
  title        = "Investing in {U.S}. Treasuries and the {T}reasury {D}irect Program",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 3,
  pages        = "14--18",
  month        = apr,
  keywords     = "t-bills, t-notes, t-bonds, inflation-linked treasuries,
    treasury direct",
  abstract     = "Treasuries have a number of features that make them extremely
    attractive to individual investors. And if you buy through Treasury Direct,
    you eliminate all commission costs as well as any cost for maintaining an
    account.",
  location     = "http://www.aaii.com/journal/article/investing-in-u-s-treasuries-and-the-treasury-direct-program"
}

@Article{bmltaomc,
  author       = "James~B. Cloonan",
  title        = "Bear Market Lessons: The Advantage of Micro-Caps",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 3,
  pages        = "33--34",
  month        = apr,
  keywords     = "cap weightings, bear markets, volatility",
  abstract     = "Another lesson to be learned from recent down markets is that
    there is a weakness in index funds. Virtually all indexes give the most
    weight to the largest companies. That makes the index fund only moderately
    diversified.",
  location     = "http://www.aaii.com/journal/article/bear-market-lessons-the-advantage-of-micro-caps"
}

@Article{mfibmahycat,
  author       = "Albert~J. Fredman",
  title        = "Mutual Fund Investors' Biggest Mistakes and How You Can Avoid Them",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 4,
  pages        = "4--6",
  month        = may,
  keywords     = "overconfidence, loss avoidance, greed, shortsightedness, cost
    blindness, investor behavior",
  abstract     = "Understanding how different investments work is the first
    step toward profitable investing. The second is making sure you—and your
    mutual fund manager—always maintain the correct wealth-building mindset.",
  location     = "http://www.aaii.com/journal/article/fund-investors-biggest-mistakes-and-how-you-can-avoid-them"
}

@Article{fecmwbmcfs,
  author       = "John Markese",
  title        = "Fund Expenses: Class Maters When Buying Multi-Class Fund Shares",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 5,
  pages        = "4--6",
  month        = jun,
  keywords     = "share classes, ",
  abstract     = "Share classes are for the same fund but involve different fee
    structures. The best class for you will vary depending on several factors,
    but the costs of choosing the wrong class can be considerable.",
  location     = "http://www.aaii.com/journal/article/fund-expenses-class-matters-when-buying-multi-class-shares"
}

@Article{dsccl,
  author       = "The DSI Team",
  title        = "{DSI}:  Secure Carrier-Class {L}inux",
  journal      = lj,
  year         = 2002,
  number       = 99,
  pages        = "92--94",
  month        = jul,
  keywords     = "security, architecture, open source",
  location     = "http://www.linuxjournal.com/article/5990"
}

@Article{kuwpt22r,
  author       = "Wesley~J. Chun",
  title        = "Keeping Up With {P}ython: The 2.2 Release",
  journal      = lj,
  year         = 2002,
  number       = 99,
  pages        = "84--90",
  month        = jul,
  keywords     = "python, sequences, iterators, generators",
  location     = "http://www.linuxjournal.com/article/5597"
}

@Article{aaacgftgp,
  author       = "Jim Kent and Heidi BrumBaugh",
  title        = "{autoSql} and {autoXml}: Code Generators from the {G}enome {P}roject",
  journal      = lj,
  year         = 2002,
  number       = 99,
  pages        = "68--77",
  month        = jul,
  keywords     = "code generation, xml, sql, dtd, schema",
  location     = "http://www.linuxjournal.com/article/5949"
}

@Article{scwgi,
  author       = "Mike Bauer",
  title        = "Staying Current without Going Insane",
  journal      = lj,
  year         = 2002,
  number       = 99,
  pages        = "38--43",
  month        = jul,
  keywords     = "system administration, software updating, package
    management, suse, red hat, debian", 
  location     = "http://www.linuxjournal.com/article/6010"
}

@Article{plkcs,
  author       = "Greg Kroah-Hartman",
  title        = "Proper {L}inux Kernel Coding Style",
  journal      = lj,
  year         = 2002,
  number       = 99,
  pages        = "20--25",
  month        = jul,
  keywords     = "naming, indentation, braces, coding standard, comments",
  location     = "http://www.linuxjournal.com/article/5780"
}

@Article{asotfami,
  author       = "Bernhard Haslhofer and Wolfgang Klas",
  title        = "{A} Survey of Techniques for Achieving Metadata Interoperability",
  journal      = surveys,
  year         = 2010,
  volume       = 42,
  number       = 2,
  pages        = "7:1--7:37",
  month        = feb,
  keywords     = "design, management, standards, metadata standards,
    interoperability, mapping, semantics, syntax",
  abstract     = "Achieving uniform access to media objects in heterogeneous
    media repositories requires dealing with the problem of metadata
    interoperability.  Currently there exist many interoperability techniques,
    with quite varying potential for resolving the structural and semantic
    heterogeneities that can exist between metadata stored in distinct
    repositories.  Besides giving a general overview of the field of metadata
    interoperability, we provide a categorization of existing interoperability
    techniques, describe their characteristics, and compare their quality by
    analyzing their potential for resolving various types of heterogeneities.
    Based on our work, domain experts and technicians get an overview and
    categorization of existing metadata interoperability techniques and can
    select the appropriate approach for their specific metadata integration
    scenarios.  Our analysis explicitly shows that metadata mapping is the
    appropriate technique in integration scenarios where an agreement on a
    certain metadata standard is not possible.",
  location     = "http://eprints.cs.univie.ac.at/79/"
}

@Article{wyntkaiibf,
  author       = "Annette Thau",
  title        = "What You Need to Know About Investing in Bond Funds",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 6,
  pages        = "10--15",
  month        = jul,
  keywords     = "expenses, returns, total return, yield, volatility, junk
    bonds, ",
  abstract     = "While bond funds share a number of characteristics with
    individual bonds, they should not be viewed as interchangeable
    investments. Indeed, bond funds differ from individual bonds in some
    important respects.",
  location     = "http://www.aaii.com/journal/article/what-you-need-to-know-about-investing-in-bond-mutual-funds"
}

@Article{moprahycat,
  author       = "James~B. Cloonan",
  title        = "Measures of Portfolio Risk and How You Can Apply Them",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 6,
  pages        = "31--34",
  abstract     = "Risk measures are only meaningful when looking at a complete
    portfolio. The risk of a single stock can be reduced by diversifying among
    different kinds of stocks, so that the overall portfolio risk is much
    lower.",
  month        = jul,
  keywords     = "standard deviation, risk-adjusted returns, ",
  location     = "http://www.aaii.com/journal/article/measures-of-portfolio-risk-and-how-you-can-apply-them"
}

@Article{eeewtrefpsu,
  author       = "John Bajkowski",
  title        = "{EBT}, {EBIT}, {EBITDA}: Will the Real Earnings Figure Please Stand Up?",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 7,
  pages        = "5--9",
  month        = aug,
  keywords     = "income statement, revenue, gross income, operating income,
    non-operating expenses, income tax, net income, cash earnings.",
  abstract     = "All of the various earnings measures have their value,
    especially when applied consistently across a given industry. But they must
    still be examined in the context of all three corporate financial
    statements.", 
  location     = "http://www.aaii.com/journal/article/ebt-ebit-ebitda-will-the-real-earnings-figure-please-stand-up-"
}

@Article{dhtgbeo,
  author       = "Albert~J. Fredman",
  title        = "Diversification: How to Get Broad Exposure Overseas",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 7,
  pages        = "10--14",
  month        = aug,
  keywords     = "currency strength, foreign stock funds, international
    indexes, exchange-traded funds, index mutual funds, ",
  abstract     = "Overseas markets have become better places to invest as
    foreign economies move toward a U.S.-style model. In addition, the recently
    expanded coverage provided by the MSCI EAFE index is good news for foreign
    index fund investors.",
  location     = "http://www.aaii.com/journal/article/diversification-how-to-get-broad-exposure-overseas"
}

@Article{httyeootsd,
  author       = "Jim Norris",
  title        = "How to Take Your Emotions Out of the Sell Decision",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 7,
  pages        = "15--18",
  month        = aug,
  keywords     = "decision making",
  abstract     = "When you decide to sell a stock, you are changing your mind
    about the stock's prospects. But changing one's mind is easier said than
    done, particularly in the investment world where uncertainty and emotions
    run high.",
  location     = "http://www.aaii.com/journal/article/2-how-to-take-your-emotions-out-of-the-sell-decision"
}

@Article{paaptcbth,
  author       = "James~B. Cloonan",
  title        = "Popular Allocation Aproaches Put the Cart Before the Horse",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 8,
  pages        = "10--12",
  month        = sep,
  keywords     = "benchmarks",
  abstract     = "Allocation may be helpful, but the key to risk control is the
    selection of the individual assets in the portfolio. Choose individual
    investments first, allocate weightings later.", 
  location     = "http://www.aaii.com/journal/article/popular-allocation-approaches-put-the-cart-before-the-horse"
}

@Article{slrcyttl,
  author       = "Jaura~J. Rittenhouse",
  title        = "Shareholder Letter Revelations: Can You Trust the Leadership?",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 8,
  pages        = "53--55",
  month        = sep,
  keywords     = "ceo letters, pr, corporate communications",
  abstract     = "The quality of management, particularly the CEO, is an
    important indicator when evaluating a company. Astute investors will look
    for evidence of the CEO's qualities in the shareholder letter.", 
  OPTlocation  = "http://www.aaii.com/journal/article/shareholder-letter-revelations-can-you-trust-the-leadership-"
}

@Article{nsistdoatc,
  author       = "Mark Hulbert",
  title        = "Newsletter Sentiment: It's the Degree of Agreement That Counts",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 8,
  pages        = "58--59",
  month        = sep,
  keywords     = "crowd wisdom, aggregate values",
  abstract     = "Rather than concentrate on the average recommendation among
    newsletters, new research focuses on the degree of dispersion among their
    various recommendations, which may be correlated with very short-term
    market phenomena.",
  location     = "http://www.aaii.com/journal/article/newsletter-sentiment-it-s-the-degree-of-agreement-that-counts"
}

@Article{lwcms,
  author       = "Michael Swane",
  title        = "Living With Compliance",
  journal      = ddj,
  year         = 2006,
  number       = 386,
  pages        = "20--26",
  month        = jul,
  keywords     = "management, scm, checks lists,",
  location     = "http://www.drdobbs.com/architecture-and-design/188700752"
}

@Article{ojmlddj,
  author       = "Matt Love",
  title        = "Optimized {J}ava",
  journal      = ddj,
  year         = 2006,
  number       = 386,
  pages        = "28--32",
  month        = jul,
  keywords     = "java 5, java 6, string building, autoboxing, escape
    analysis, storage management tuning", 
  location     = "http://www.drdobbs.com/jvm/188700760"
}

@Article{rcpj,
  author       = "Tea Vul Huang",
  title        = "Radios, Cell Phones, \& {J}ava",
  journal      = ddj,
  year         = 2006,
  number       = 386,
  pages        = "34--41",
  month        = jul,
  keywords     = "tuners, sr-234, signal strength, amms",
  location     = "http://www.drdobbs.com/embedded-systems/188700762"
}

@Article{aapcbswa,
  author       = "Cliff Berg and Scott~W. Ambler",
  title        = "Assurances \& Agile Processes",
  journal      = ddj,
  year         = 2006,
  number       = 286,
  pages        = "42--45",
  month        = jul,
  keywords     = "assurance design, emergent properties, agile modeling",
  location     = "http://www.drdobbs.com/architecture-and-design/188700785"
}

@Article{tanmt,
  author       = "Michael Taylor",
  title        = "Threading and .{NET}",
  journal      = ddj,
  year         = 2006,
  number       = 386,
  pages        = "46--49",
  month        = jul,
  keywords     = "work items, pausing, resuming, work-item termination, thread
  management, ui updates, multitasking"
}

@Article{scctsh,
  author       = "Stephen Hutton",
  title        = "Supporting Custom " # cpp # " Types",
  journal      = ddj,
  year         = 2006,
  number       = 386,
  pages        = "50--54",
  month        = jul,
  keywords     = "type support, traits, aggregate types, object-relational
    mapping",
  location     = "http://www.drdobbs.com/cpp/188700800"
}

@Article{lbtrpi,
  author       = "Pete Becker",
  title        = "Living By The Rules:  Part {II}",
  journal      = ddj,
  year         = 2006,
  number       = 386,
  pages        = "55--",
  month        = jul,
  keywords     = "common mistakes, extensions, stl algorithms, library
    interfaces, floating point, c99 compatibility",
  location     = "http://www.drdobbs.com/cpp/188700816"
}

@Article{iehcr,
  author       = "Jinwook Seo and Ben Shneiderman",
  title        = "Interactively Exploring Hierarchical Clustering Results",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "80--86",
  month        = jul,
  keywords     = "hierarchical clustering, visualization, ",
  abstract     = "To date, work in microarrays, sequenced genomes, and
    bioinformatics has focused largely on algorithmic methods for processing
    and manipulating vast biological data sets.  Future improvements will
    likely provide users with guidance in selecting the most appropriate
    algorithms and metrics for identifying meaningful clusters--interesting
    patterns in large data sets, such asgroups of genes with similar profiles.
    Hierarchical clustering has been shown to be effective in microarray data
    analysis for identifying genes with similar profiles and thus possibly with
    similarfunctions.  Users also need an efficient visualization tool,
    however, to facilitate pattern extraction from microarray data sets.The
    Hierarchical Clustering Explorer integrates four interactive features to
    provide information visualization techniques that allow users to control
    the processes and interact with the results.  Thus, hybrid approaches that
    combine powerful algorithms with interactive visualization tools will join
    the strengths of fast processors with the detailed understanding of domain
    experts.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1016905"
}

@Article{arwdtgdeiv ,
  author       = "Salvatore Paxia and Archisman Rudra and Yi Zhou and Bud Mishra",
  title        = "A Random Walk Down the Genomes: {DNA} Evolution in {V}alis",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "73--79",
  month        = jul,
  keywords     = "long-range correlations, in silico evolution, genomic evnets,
    genome grammar, generic modeling",
  abstract     = "A better understanding of biology will come through
    information-theoretic studies of genomes that pro-vide insights into DNA's
    role in governing metabolic and regulatory pathways.Understanding the
    evolutionary processes that act on these codes of life requiresthe ability
    to analyze vast amounts of continually generated genomic data.Researchers
    in the emerging bioinformatics discipline require more complex mechanisms
    to investigate the full ensemble of available biological facts.  To meet
    this challenge, New York University's Bioinformatics Group is creating a
    computational environment called Valis--the vast active living intelligent
    system.  Valis is designed to solve the immediate genomic and proteomic
    problems that the biological community currently faces, while remaining
    flexible enough to adapt to the maturing bioinformatics field.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1016904"
}

@Article{baibsfsp ,
  author       = "Bahram Parvin and Qing Yang and Gerald Fontenay and Mary Helen Barcellos-Hoff",
  title        = "{BioSig}: An Imaging Bioinformatic System for Studying Phenomics",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "65--71",
  month        = jul,
  keywords     = "cellular signaling, nuclei extraction, in vivo studies",
  abstract     = "Using genomic information to understand complex organisms
    requires comprehensive knowledgeof the dynamics of phenotype generation and
    maintenance.  A phenotype results from selective expression of the genome,
    creating a history of the cell and its response to the extracellular
    environment.  Defining cell phenomes requires tracking the kinetics and
    quantities ofmultiple constituent proteins, their cellular context, and
    their morphologicalfeatures in large populations.The BioSig imaging
    bioinformatic system for characterizing phenomicsanswers these challenges.
    The BioSig approach to microscopy and quantitative image analysis helps to
    build a more detailed picture of the signaling that occurs between cells as
    a response toexogenous stimulus such as radiation or as a consequence of
    endogenous programs leading to biological functions.  The system provides a
    data model for capturing experimental annotations and variables,
    computational techniques for summarizing large numbers of images, and a
    distributedarchitecture that facilitates distant collaboration.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1016903"
}

@Article{tnsfcp,
  author       = "Bernard M.~E. Moret and Li-San Wang and Tandy Warnow",
  title        = "Toward New Software for Computational Phylogenetics",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "55--64",
  month        = jul,
  keywords     = "reconstruction, biomolecular sequences, genomes",
  abstract     = "Systematists study how a group of genes or organisms evolved.
    These biologists now have set their sights on the Tree of Life challenge:
    to reconstruct the evolutionary history of all known living organisms.A
    typical phylogenetic reconstruction starts with biomolecular data, such as
    DNA sequences for modern organisms, and builds a tree, or phylogeny, for
    these sequences that represents a hypothesized evolutionary history.
    Finding the best tree for a data set can be a computationally intensive
    problem.Phylogenetic software for mapping the Tree of Life will require
    entirely new approaches in statistical models of evolution,
    high-performance implementations, and data analysis and visualization.  The
    authors have developed polynomial algorithmic techniques for use in their
    research addressing phylogeny reconstruction from biomolecular sequences,
    focusing on the accuracy of reconstructions and the use of simulations.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1016902"
}

@Article{gsaaai,
  author       = "Mihai Pop and Steven~L. Salzberg and Martin Shumway",
  title        = "Genome Sequence Assembly: Algorithms and Issues",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "47--54",
  month        = jul,
  keywords     = "shotgun sequencing, clones, repeats",
  abstract     = "Ultimately, genome sequencing seeks to provide an organism's
    complete DNA sequence.  Automation of DNA sequencing allowed scientists to
    decode entire genomes and gave birth to genomics, the analytic and
    comparative study of genomes.  Although genomes can include billions of
    nucleotides, the chemical reactions researchers use to decode the DNA are
    accurate for only about 600 to 700 nucleotides at a time.The DNA reads that
    sequencing produces must then be assembled into a complete picture of the
    genome.  Errors and certain DNA characteristics complicate assembly.
    Resolving these problems entails an additional and costly finishing phase
    that involves extensive human intervention.  Assembly programs can
    dramatically reduce this cost by taking into account additional
    informationobtained during finishing.  Algorithms that can assemble
    millions of DNA fragments into gene sequences underlie the current
    revolution in biotechnology, helping researchers build the growingdatabase
    of complete genomes.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1016901"
}

@Article{cafmoafv,
  author       = "Junhyong Kim",
  title        = "Computers Are from {M}ars, Organisms Are from {V}enus",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "25--32",
  month        = jul,
  keywords     = "computational biology, dna computing, genetic algorithms",
  abstract     = "Biology and computer science share a natural affinity.
    Physicist Erwin Schrödinger envisioned life as an aperiodic crystal,
    observing that the organizing structure of life is neither completely
    regular, like a pure crystal, nor completely chaotic and without structure,
    like dust in the wind.  Perhaps this is why biological information has
    never satisfactorily yielded to classical mathematical analysis.Machine
    computations combine elegant algorithms with brute-force
    calculations--which seems a reasonable approach to this aperiodic
    structure.  Likewise, computing seeks to create a machine that can flexibly
    solve diverse problems.  In nature, such plastic problem solving resides
    uniquely in the domain of organic matter.  Thus, examining how organisms
    solve problems can lead to new computation- and algorithm-development
    approaches that devour the problems that are so easy to approach using a
    computer, yet so difficult to tackle in the laboratory.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1016898"
}

@Article{wsdas,
  author       = "Roberto Navigli",
  title        = "Word Sense Disambiguation: {A} Survey",
  journal      = surveys,
  year         = 2009,
  volume       = 41,
  number       = 2,
  pages        = "10:1--10:29",
  month        = jul,
  keywords     = "algorithms, experimentation, measurement, performance, word
    sense disambiguation, worde sense discrimination, wsd, lexical semantics,
    lexical ambiguity, sense annotation, semantic annotation",
  abstract     = "Word sense disambiguation (WSD) is the ability to identify
    the meaning of words in context in a computational manner.  WSD is
    considered an AI-complete problem, that is, a task whose solution is at
    least as hard as the most difficult problems in artificial intelligence.
    We introduce the reader to the motivations for solving the ambiguity of
    words and provide a description of the task.  We overview supervised,
    unsupervised, and knowledge-based approaches.  The assessment of WSD
    systems is discussed in the context of the Senseval/Semeval campaigns,
    aiming at the objective evaluation of systems participating in several
    different disambiguation tasks.  Finally, applications, open problems, and
    future directions are discussed.", 
  location     = "http://dx.doi.org/10.1145/1459352.1459355"
}

@Article{dapitip,
  author       = "Pedro Sousa and Manuel Sequeira and Andr{\' e} Z{\' u}quete
    and Paulo Ferreira and Cristina Lopes and Jos{\' e} Pereira and  Paulo
    Guedes and Jos{\' e} Alves Marques", 
  title        = "Distribution and Persistence in the {IK} Platform",
  journal      = "Computer Systems",
  year         = 1993,
  volume       = 6,
  number       = 4,
  pages        = "392--424",
  month        = "Fall",
  keywords     = "object sharing, method invocation, object kernel, ",
  abstract     = "IK is an object-oriented platform that simplifies the 
    construction of applications that handle persistent and distributed data.
    A single programming paradigm is used to manipulate volatile, persistent
    anddistributed objects uniformly.  Object invocation is the basic primitive
    of the system, embodying all the features required for transparent handling
    of persistence and distribution.  Object references can be freely passed as
    parameters in remote invocations or stored persistently.  Objects are
    initially created as volatile and are automatically recycled when they are
    no longer referenced.  Objects are promoted to persistent when they become
    reachable from a persistent root.  Persistent objects are read from disk on
    demand when they are invoked and are written back to disk when the
    application terminates.  Applications are written in a language similar to
    C#, but with some semantic differences.  Classes are represented as special
    persistent objects.  They are dynamically linked when needed and can be
    updated at run-time to install a newer version of the code.  This paper
    contains a technical description of IK and an evaluation based on two years
    of experience in using the system to build applications.", 
  location     = "http://www.usenix.org/publications/compsystems/1993/fall_sousa.pdf"
}

@Article{oadafos,
  author       = "Roy Hunter and Per Kaijser and Frances~H. Nielsen",
  title        = "{ODA}: {A} Document Architecture for Open Systems",
  journal      = "Computer Communications",
  year         = 1989,
  volume       = 12,
  number       = 2,
  pages        = "69--79",
  month        = apr,
  keywords     = "document architecture, logical structure, layout structure,
    content architectures, office information systemsw, office document
    architecture, document interchange, open systems interconnection",
  abstract     = "The main concepts and aims of the new ISO 8613 standard - 
    generally referred to as Office Document Architecture - that has been
    jointly published by the International Organization for Standardization and
    the Consultative Committee on International Telephone and Telegraph, is
    described here.  ODA provides a general information architecture which can
    be used as a basis for encoding documents so that they can be transferred
    between dissimilar document processing systems.  The architecture supports
    the representation of multi-media documents (containing text, raster
    graphics and computer graphics) in both revisable and final forms.  ODA is
    expected to have a significant role in the integration of office systems,
    particularly those that operate in an open systems interconnection
    environment.", 
  location     = "http://dx.doi.org/10.1016/0140-3664(89)90060-1"
}

@Article{smnwpaic,
  author       = "John Mitchell and Ramesh Viswanathan",
  title        = "Standard {ML}–{NJ} Weak Polymorphism and Imperative Constructs",
  journal      = "Information and Computation",
  year         = 1993,
  volume       = 127,
  number       = 2,
  pages        = "102--116",
  month        = jun,
  keywords     = "weak polymorphism, operational semantics, type expressions,
    typing rules, soundness, type inference",
  abstract     = {Standard ML of New Jersey (SML–NJ) uses “weak type variables”
    to restrict the polymorphic use of functions that may allocate reference
    cells, manipulate continuations, or use exceptions.  However, the type
    system used in the SML–NJ compiler has not previously been presented in a
    form other than source code nor proved correct.  We present a set of typing
    rules, based on analysis of the concepts underlying “weak polymorphism”,
    that appears to subsume the implemented algorithm and uses type variables
    of only a slightly more general nature than the compiler.  One insight in
    the analysis is that allowing a variable to occur both “ordinarily” and
    “weakly” in a type permits a simpler and more flexible formulation of the
    typing rules.  In particular, we are able to treat applications of
    polymorphic functions to imperative arguments with greater flexibility than
    SML–NJ.  The soundness of the type system is proved for imperative code
    using operational semantics, by showing that evaluation preserves
    typability.  By incorporating assumptions about memory addresses in the
    type system, we avoid proofs by co-induction.},
  location     = "http://theory.stanford.edu/people/jcm/papers/weak-poly.ps"
}

@Article{sfsd,
  author       = "Heather Brown",
  title        = "Standards for Structured Documents",
  journal      = tcj,
  year         = 1989,
  volume       = 32,
  number       = 6,
  pages        = "505--514",
  month        = dec,
  keywords     = "oda structures, layout, interchange formats, sgml markup,
    document type definitions, sgml",
  abstract     = "Recent work with electronic documents has emphasised the 
    importance of maintaining the structure of a document at all stages of
    editing, storage and transmission.  The Office Document Architecture (ODA)
    and the Standard Generalised Markup Language (SGML) are two international
    standards for the representation and interchange ofstructured documents.
    This paper outlines the main features of the document structures supported
    by ODA and SGML and assesses their strengths and weaknesses.", 
  location     = "http://comjnl.oxfordjournals.org/content/32/6/505.full.pdf"
}

@Article{itataok,
  author       = "Tara Brabazon",
  title        = "Internet Teaching and the Administration of Knowledge",
  journal      = "First Monday",
  year         = 2001,
  volume       = 6,
  number       = 6,
  month        = jun,
  keywords     = "education, internet",
  location     = "http://firstmonday.org/htbin/cgiwrap/bin/ojs/index.php/fm/article/viewArticle/867/776"
}

@Article{ymfpctloc,
  author       = "John Markese",
  title        = "Your Mutual Fund Portfolio: Choosing the Level of Complexity",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 10,
  pages        = "4--6",
  month        = nov,
  keywords     = "complexity, portfolio composition",
  abstract     = "Using the three-tiered mutual fund portfolio guideline, you
    can create any mutual fund portfolio you want that comfortably matches your
    investor profile in terms of complexity, yet still remain properly
    diversified.", 
  location     = "http://www.aaii.com/investing/article/your-mutual-fund-portfolio-choosing-the-level-of-complexity"
}

@Article{mvmdtfmrw,
  author       = "Stephen~E. Wilcox",
  title        = "Market Valuation Measures: Does the {F}ed {M}odel Really Work?",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 10,
  pages        = "7--10",
  month        = nov,
  keywords     = "return on equity, performance measurement",
  abstract     = "There's a real danger in placing too much emphasis on the Fed
    Model when determining your asset allocation, particularly during the
    current market environment.",
  location     = "http://www.aaii.com/journal/article/market-valuation-measures-does-the-fed-model-really-work-"
}

@Article{aaarhtbyop,
  author       = "James~B. Cloonan",
  title        = "Asset Allocation and Risk: How to Build Your Own Portfolio",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 10,
  pages        = "11--15",
  month        = nov,
  keywords     = "diversification, volatility, returns, cap weighting, risk",
  abstract     = "There are two steps to developing a truly diversified
    portfolio that meets your personal needs: Set a level of risk you can live
    with, and pick the individual assets and classes that will provide the
    highest return within that risk level.",
  location     = "http://www.aaii.com/journal/article/asset-allocation-and-risk-how-to-build-your-own-portfolio"
}

@Article{tfatiiscs,
  author       = "Wayne~A. Thorp",
  title        = "The {F}oolish Approach to Investing in Small-Cap Stocks",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 10,
  pages        = "23--26",
  month        = nov,
  keywords     = "motley fool, stock screening, profit margin, cash flow,
    liquidity, growth, price, performance",
  abstract     = "The Motley Fool's Foolish 8 method for investing in small
    caps looks for profitable and rapidly growing companies with strong price
    momentum.",
  location     = "http://www.aaii.com/journal/article/the-foolish-approach-to-investing-in-small-cap-stocks"
}

@Article{tiiolsrp,
  author       = "William Reichenstein",
  title        = "The Investment Implications of Lower Stock Return Prospects",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 9,
  pages        = "4--7",
  month        = oct,
  keywords     = "investment, stock returns, asset classes, portfolio
    management",
  abstract     = "There is a strong consensus among academics and professionals
    that long-run U.S. stock prospects are below average. Market multiples,
    which even with the market decline are well above average, suggest
    below-average future prospects.", 
  location     = "http://www.aaii.com/journal/article/the-investment-implications-of-lower-stock-return-prospects"
}

@Article{uptsrfoofs,
  author       = "John Bajkowski",
  title        = "Using Price-to-Sales Ratios for Out-of-Favor Stocks",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 9,
  pages        = "8--12",
  month        = oct,
  keywords     = "industry levels, conditioning criterion, financial leverage,
    relative price strngth, firm size",
  abstract     = "Stock Screening: Proponents of price-to-sales ratios argue
    that sales-based valuations are better than earnings-based ones because
    sales is subject to fewer assumptions, interpretations and manipulations.",
  location     = "http://www.aaii.com/journal/article/using-price-to-sales-ratios-for-out-of-favor-stocks"
}

@Article{iiismstd,
  author       = "Albert~J. Fredman",
  title        = "International Investing: It Still Makes Sense to Diversify",
  journal      = aaiij,
  year         = 2001,
  volume       = 23,
  number       = 9,
  pages        = "13--17",
  month        = oct,
  keywords     = "correlations, currency fluctuations, performance, emerging
    markets",
  abstract     = "Correlations among the world's major markets often converge 
    during brief U.S. market shocks. The heavy selling typically produces a
    worldwide domino effect during severe global traumas.", 
  location     = "http://www.aaii.com/journal/article/international-investing-it-still-makes-sense-to-diversify"
}

@Article{tbfl,
  author       = "Dror~G. Feitelson and Millet Treinin",
  title        = "The Blueprint for Life?",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 7,
  pages        = "34--39",
  month        = jul,
  keywords     = "dna decoding, information storage, cellular state machines",
  abstract     = "One of the greatest scientific discoveries of the twentieth
    century is the structure of DNA and how it encodes proteins.  Current
    genome projects, especially the Human Genome Project, have sparked interest
    in the information encoded in DNA, which is often referred to as the
    blueprint for life,implying that it contains all the information needed to
    create life.  But this interpretation ignores the complex interactions
    between DNA and its cellular environment--interactions that regulate and
    control the spatial and temporal patterns of gene expression.  Moreover,
    the particulars of many cellular structures seem not to be encoded in DNA,
    and they are never created from scratch--rather,each cell inherits
    templates for these structures from its parent cell.  Thus, it is not clear
    that DNAdirectly or indirectly encodes all life processes, casting doubt on
    the belief that we can understand them solely by studying DNA sequences.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1016899"
}

@Article{wyntkaiimb,
  author       = "Annette Thau",
  title        = "What You Need to Know About Investing in Municipal Bonds",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 9,
  pages        = "4--8",
  month        = oct,
  keywords     = "municipal bonds, credit quality, bond ratings, revenue bonds,
    general obligation bonds, insurance, quality",
  abstract     = "Munis deserve their popularity among individual investors.
  They are sound and relatively uncomplicated instruments.  Nonetheless, buying
  individual municipal bonds is not quite as simple as buying Treasuries.", 
  location     = "http://www.aaii.com/journal/article/2-what-you-need-to-know-about-investing-in-municipal-bonds"
}

@Article{dcsfuswlr,
  author       = "Paula~H. Hogan",
  title        = "Dividends Count: Screening for Undervalued Stocks With Lower Risk",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 9,
  pages        = "17--19",
  month        = oct,
  keywords     = "dividend-yield, payout ratio, financial strength, earnings
    strength", 
  abstract     = "If a stock's price rises faster than its dividend, the
    dividend yield will fall, indicating the price may have been bid up too
    far.  Conversely, if the yield rises to a high level, the stock may be
    poised for an increase.", 
  location     = "http://www.aaii.com/journal/article/dividends-count-screening-for-undervalued-stocks-with-lower-risk"
}

@Article{aaabftbu,
  author       = "James~B. Cloonan",
  title        = "Asset Allocation Approaches: Building From the Bottom Up",
  journal      = aaiij,
  year         = 2002,
  volume       = 24,
  number       = 9,
  pages        = "27--30",
  month        = oct,
  keywords     = "rebalancing, portfolio selection, asset classes",
  abstract     = "To reduce risk, an investor needs to add to his portfolio
    holdings that have both good prospects and low correlations with other
    holdings.  Whether those assets belong to a particular class is not
    important.",
  location     = "http://www.aaii.com/journal/article/asset-allocation-approaches-building-from-the-bottom-up"
}

@Article{btaaaacvate,
  author       = "William Reichenstein",
  title        = "Basic Truths About Asset Allocation:  {A} Consensus View Among the Experts",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 9,
  pages        = "7--10",
  month        = oct,
  keywords     = "asset mixes, international investments, fixed weight,
    rebalancing, portfolio risk, stock exposure",
  abstract     = "The widespread consensus among investment professionals
    reveals basic truths concerning the appropriate asset mix for the typical
    investor.", 
  location     = "http://www.aaii.com/journal/article/basic-truths-about-asset-allocation-a-consensus-view-among-the-experts"
}

@Article{uptsrtsfoofs,
  author       = "John Bajkowski",
  title        = "Using Price-to-Sales Ratios to Screen for Out-of-Favor Stocks",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 9,
  pages        = "13--16",
  month        = oct,
  keywords     = "financial leverage, relative price strength, firm size",
  abstract     = "Stock Analysis Workshop: Research suggests that the
    price-to-sales ratio may be a better determinant of undervalued stocks than
    price-earnings ratio. Building a screen based on the price-to-sales ratio.",
  location     = "http://www.aaii.com/journal/article/using-price-to-sales-ratios-to-screen-for-out-of-favor-stocks"
}

@Article{haydmamaip,
  author       = "Maria Crawford Scott",
  title        = "How Are You Doing? Measuring and Monitoring an Investment Portfolio",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 9,
  pages        = "20--22",
  month        = oct,
  keywords     = "portfolio evaluation, approximate returns",
  abstract     = "Evaluating your investment portfolio periodically involves
    measuring the components and the whole, as well as checking the allocation
    for rebalancing needs. A case study shows how to carry out these steps.",
  location     = "http://www.aaii.com/journal/article/how-are-you-doing-measuring-and-monitoring-an-investment-portfolio"
}

@Article{anrociwwc,
  author       = "Albert~J. Fredman",
  title        = "{A} New Route Overseas: Country Indexing With {WEBS} \& {CountryBaskets}",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 9,
  pages        = "23--27",
  month        = oct,
  keywords     = "creation units, net assets, expenses, volume, liquidity,
    closed-end funds",
  abstract     = "New index products give investors another route to investing
    in individual countries: CountryBaskets and WEBS.", 
  location     = "http://www.aaii.com/journal/article/a-new-route-overseas-country-indexing-with-webs-countrybaskets"
}

@Article{alastcoqa,
  author       = "James~B. Cloonan",
  title        = "{A} Look at Style: The Characteristics of Quantitative Approaches",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 9,
  pages        = "32--33",
  month        = oct,
  keywords     = "market capitalization, earnings per share, price",
  abstract     = "The rules under a quantitative approach should be specific
    enough that they could be programmed into a computer, although complete
    automation is impractical.", 
  location     = "http://www.aaii.com/journal/article/a-look-at-style-the-characteristics-of-quantitative-approaches"
}

@Article{acasfvotm,
  author       = "John Bajkowski",
  title        = "{A} Combination Approach:  Screens for Value on the Move",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 3,
  pages        = "6--9",
  month        = apr,
  keywords     = "peg ratio, p/e ratio, earnings growth, price momentum",
  abstract     = "Screening just for stocks with low P/Es may leave you with a
    list of firms with no growth prospects. Adding growth screens can help you 
    identify reasonably priced stocks with some momentum.", 
  location     = "http://www.aaii.com/journal/article/a-combination-approach-screens-for-value-on-the-move"
}

@Article{btngtkam,
  author       = "Maria Crawford Scott",
  title        = "Beyond the Numbers: Getting to Know a Manager",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 3,
  pages        = "10--14",
  month        = apr,
  keywords     = "investment philosophy, stock universe, screen criteria, tie
    breakers, stock valuation, non-financial characteristics, market timing,
    technical characteristics, risk reduction, sell triggers",
  abstract     = "At some point you have to look beyond the performance
    statistics to see who made them happen, so you can form some kind of
    judgment about future performance.",
  location     = "http://www.aaii.com/journal/article/2-beyond-the-numbers-getting-to-know-a-manager"
}

@Article{htctroyp,
  author       = "Maria Crawford Scott",
  title        = "How to Calculate the Return on your Portfolio",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 3,
  pages        = "15--18",
  month        = apr,
  keywords     = "return, approximate returns, time weighted returns, weighted
    portfolio returns",
  abstract     = "For portfolios with significant additions or withdrawals,
    determining the return can be complex, and the approach used depends in
    part on what you are trying to measure.", 
  location     = "http://www.aaii.com/journal/article/how-to-calculate-the-return-on-your-portfolio"
}

@Article{iithgat,
  author       = "Robert~J. Angell and Alonzo~L. Redmon",
  title        = "Inflation-Indexed Treasuries: How Good Are They?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 3,
  pages        = "22--24",
  month        = apr,
  keywords     = "inflation, tips, taxation",
  abstract     = "Inflation-indexed Treasuries were designed to protect
    fixed-income investors from inflation, but the way in which they are taxed
    decreases the protection, and investors need to be aware of the
    limitations.",
  location     = "http://www.aaii.com/journal/article/inflation-indexed-treasuries-how-good-are-they-"
}

@Article{jhianth,
  author       = "Mark Hulbert",
  title        = "Just How Important Are Newsletters' Telephone Hotlines?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 3,
  pages        = "29--31",
  month        = apr,
  keywords     = "newsletters, hotlines",
  abstract     = "Investors seem to prefer newsletters that have hotlines. But
    do newsletters with hotlines perform any better than those without? A look
    at the numbers.", 
  location     = "http://www.aaii.com/journal/article/just-how-important-are-newsletters-telephone-hotlines-"
}

@Article{tbfarri,
  author       = "John Markese",
  title        = "Treasury Bond Funds:  {A} Risky Riskless Investment?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 1,
  pages        = "3--5",
  month        = jan,
  keywords     = "bond prices, maturity, interest-rate risk, call risk",
  abstract     = "Risk factors to consider before investing in riskless
    Treasury bond funds.",
  location     = "http://www.aaii.com/journal/article/treasury-bond-funds-a-risky-riskless-investment-"
}

@Article{jacrfigiapf,
  author       = "James~B. Cloonan",
  title        = "Just Another Commodity: Reasons for Including Gold in a Portfolio Fade",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 1,
  pages        = "12",
  month        = jan,
  keywords     = "commodity, gold, investment",
  abstract     = "Gold no longer offers much of a financial benefit to
    individual investors other than price speculation, the same as any other
    commodity.", 
  location     = "http://www.aaii.com/journal/article/just-another-commodity-reasons-for-including-gold-in-a-portfolio-fade"
}

@Article{tbkptcwisaccbf,
  author       = "John Markese",
  title        = "Tie-Breakers: Key Points to Consider When It's a Close Call Between Funds",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 10,
  pages        = "3--5",
  month        = nov,
  keywords     = "risk, aftertax returns, fund size, expense ratio, portfolio
    manager tenure, loads",
  abstract     = "Mutual Funds Workshop: Factors to consider that can help
  break a tie when choosing between similar funds.",
  location     = "http://www.aaii.com/journal/article/tie-breakers-key-points-to-consider-when-it-s-a-close-call-between-funds"
}

@Article{pawtrltrpsu,
  author       = "Maria Crawford Scott",
  title        = "Planning Assumptions: Will the Real Long-Term Return Please Stand Up?",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 10,
  pages        = "10--12",
  month        = nov,
  keywords     = "returns, performance",
  abstract     = "Long-term return assumptions are key to any financial
    plan. But long-term returns vary substantially. Which one  should you
    use?", 
  location     = "http://www.aaii.com/journal/article/planning-assumptions-will-the-real-long-term-return-please-stand-up-"
}

@Article{wpsitbfffain,
  author       = "Mark Hulbert",
  title        = "What Portfolio Size Is the Best Fit for Following an Investment Newsletter?",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 10,
  pages        = "28--30",
  month        = nov,
  keywords     = "commissions, ",
  abstract     = "Some newsletters have large model portfolios, trade
    frequently, and are appropriate only for large investor portfolios. Others
    work quite well for small portfolios.", 
  location     = "http://www.aaii.com/journal/article/what-portfolio-size-is-the-best-fit-for-following-an-investment-newsletter-"
}

@Article{sfsutcis,
  author       = "John Bajkowski",
  title        = "Screening for Stocks Using the Contrarian Investment Strategy",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 9,
  pages        = "3--6",
  month        = oct,
  keywords     = "p/e ratio, company size, financial strength, dividend yield,
    earnings growth, diversification",
  abstract     = "Applying the David Dreman approach using the Stock Investor
    screening program.", 
  location     = "http://www.aaii.com/journal/article/screening-for-stocks-using-the-contrarian-investment-strategy"
}

@Article{wacapoytip,
  author       = "Maria Crawford Scott",
  title        = "What Assets ``Count'' as Part of Your Total Investment Portfolio?",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 9,
  pages        = "7--9",
  month        = oct,
  keywords     = "assets, investments, portfolios",
  abstract     = "Sorting out which assets to include and exclude when defining
  your investment portfolio: A case study.",
  location     = "http://www.aaii.com/journal/article/what-assets-count-as-part-of-your-total-investment-portfolio-"
}

@Article{biahtmaid,
  author       = "Frank Campanale and Brett Skakun",
  title        = "Behavioral Idiosyncrasies and How They May Affect Investment Decisions",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 9,
  pages        = "13--17",
  month        = oct,
  keywords     = "herd mentalities, regret aversion, ownership pride",
  abstract     = "Simple human nature sometimes causes investors to veer from
    rational decisions that would best serve long-term financial
    goals. Understanding these behavioral quirks can help you take the emotion
    out of the analysis when making decisions.",
  location     = "http://www.aaii.com/journal/article/behavioral-idiosyncrasies-and-how-they-may-affect-investment-decisions"
}

@Article{taiipucecf,
  author       = "Albert~J. Fredman",
  title        = "Tailoring an International Investment Portfolio Using Closed-End Country Funds",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 9,
  pages        = "20--25",
  month        = oct,
  keywords     = "inefficiencies, single-country funds, region funds",
  abstract     = "Closed-end funds are more complicated than their open-end
    siblings, but they also offer special attractions, such as the ability to
    purchase them at double-digit discounts.", 
  location     = "http://www.aaii.com/journal/article/tailoring-an-international-investment-portfolio-using-closed-end-country-funds"
}

@Article{dwsartdwalp,
  author       = "James~B. Cloonan",
  title        = "Dealing With Success: Adjusting Rules to Deal With a Larger Portfolio",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 9,
  pages        = "33",
  month        = oct,
  keywords     = "portfolio size, investment",
  abstract     = "The growth in value of the Beginner's Portfolio prompts some
    revisions of the original rules regarding company size, number of stocks
    held, and reasons for selling.", 
  location     = "http://www.aaii.com/journal/article/dealing-with-success-adjusting-rules-to-deal-with-a-larger-portfolio"
}

@Article{tiisgtmfs,
  author       = "John Markese",
  title        = "The Individual Investor's Guide to Mutual Fund Supermarkets",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 8,
  pages        = "3--5",
  month        = sep,
  keywords     = "fees, discounts, trading",
  abstract     = "Discount brokers that offer no-transaction-fee mutual funds
    are proliferating and rapidly expanding the universe of their offerings.", 
  location     = "http://www.aaii.com/journal/article/the-individual-investor-s-guide-to-mutual-fund-supermarkets"
}

@Article{aagatiieb,
  author       = "Maria Crawford Scott",
  title        = "An Aggressive Growth Approach to Investing in Expanding Businesses",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 8,
  pages        = "6--10",
  month        = sep,
  keywords     = "growth stock, stock monitoring",
  abstract     = "A look at David Alger's approach to stock selection explains
    where he finds growth stocks and how he places a value on them.",
  location     = "http://www.aaii.com/journal/article/an-aggressive-growth-approach-to-investing-in-expanding-businesses"
}

@Article{wtgmrtaoabm,
  author       = "Mark Hulbert",
  title        = "What the Gold Market Reveals: The Anatomy of a Bear Market",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 8,
  pages        = "27--29",
  month        = sep,
  keywords     = "gold, bear markets, timing",
  abstract     = "Can you keep your buy-and-hold convictions during a bear
    market? If you can't, it's better to know sooner--while we re still in a
    bull market--rather than later.", 
  location     = "http://www.aaii.com/journal/article/what-the-gold-market-reveals-the-anatomy-of-a-bear-market"
}

@Article{hybfpoibhmar,
  author       = "John Markese",
  title        = "High-Yield Bond Funds:  Plenty of Income, But How Much Added Risk?",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 7,
  pages        = "2--5",
  month        = aug,
  keywords     = "bond funds, debt ratings, fund holdings",
  abstract     = "A look at high-yield bond funds--their recent success and the
    accompanying risks.", 
  location     = "http://www.aaii.com/journal/article/high-yield-bond-funds-plenty-of-income-but-how-much-added-risk-"
}

@Article{sswmalarsm,
  author       = "John Bajkowski",
  title        = "Seeking Stocks With Momentum: {A} Look at Relative Strength Measures",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 7,
  pages        = "6--8",
  month        = aug,
  keywords     = "relative strength, rankings",
  abstract     = "Where to find a stock's relative strength and how this
    momentum indicator is calculated.", 
  location     = "http://www.aaii.com/journal/article/seeking-stocks-with-momentum-a-look-at-relative-strength-measures"
}

@Article{pratpwbm,
  author       = "Maria Crawford Scott",
  title        = "Portfolio Rebalancing and the ``Problem'' With Bull Markets",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 7,
  pages        = "9--12",
  month        = aug,
  keywords     = "rebalancing, portfolio management, bull markets",
  abstract     = "How to keep your portfolio allocations balanced throughout a
    strong bull market.", 
  location     = "http://www.aaii.com/journal/article/portfolio-rebalancing-and-the-problem-with-bull-markets"
}

@Article{etlotmbetegr,
  author       = "Robert~J. Angell and Alonzo Redmon",
  title        = "Evaluating the Level of the Market by Examining the Expected Growth Rate",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 7,
  pages        = "20--21",
  month        = aug,
  keywords     = "growth rate, pe ratios, ",
  abstract     = "Current price-earnings ratios can be evaluated by calculating
    the growth rate in earnings and dividends implied by the market data.", 
  location     = "http://www.aaii.com/journal/article/evaluating-the-level-of-the-market-by-examining-the-expected-growth-rate"
}

@Article{gatcalatcis,
  author       = "Maria Crawford Scott",
  title        = "Going Against the Crowd: {A} Look at The Contrarian Investment Strategy",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 6,
  pages        = "2--5",
  month        = jul,
  keywords     = "contrarian investing",
  abstract     = "",
  location     = ""
}

@Article{hsablamips,
  author       = "Robert~T. Kleiman and Anandi~P. Sahu",
  title        = "Hybrid Securities: {A} Basic Look at Monthly Income Preferred Stock",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 6,
  pages        = "14--17",
  month        = jul,
  keywords     = "mips, quips, toprs",
  abstract     = "",
  location     = ""
}

@Article{wittttmawtdai,
  author       = "James~B. Cloonan",
  title        = "Why Investors Tend to Trade Too Much---And What to Do About It",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 6,
  pages        = "21--22",
  month        = jul,
  keywords     = "selling time, self-knowledge",
  abstract     = "",
  location     = ""
}

@Article{tsotsftfomcc,
  author       = "Albert~J. Fredman",
  title        = "The Smallest of the Small:  Funds That Focus on Micro-Cap Companies",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 6,
  pages        = "23--27",
  month        = jul,
  keywords     = "micro caps, benchmarks, returns",
  abstract     = "",
  location     = ""
}

@Article{atcoaamf,
  author       = "John Markese",
  title        = "Assessing the Characteristicxsw of Asset Allocation Mutual Funds",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 5,
  pages        = "2--5",
  month        = jun,
  keywords     = "performance, benchmarking, statistics",
  abstract     = "Asset allocation funds--a look at their similarities and
    differences.", 
  location     = "http://www.aaii.com/journal/article/assessing-the-characteristics-of-asset-allocation-mutual-funds"
}

@Article{icofwdrp,
  author       = "John Bajkowski",
  title        = "Investment Characteristics of Firms With Dividend Reinvestment Plans",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 5,
  pages        = "6--10",
  month        = jun,
  keywords     = "dividend reinvestment plans",
  abstract     = "A look at the investment characteristics of companies that
    offer dividend reinvestment plans.", 
  location     = "http://www.aaii.com/journal/article/2-investment-characteristics-of-firms-with-dividend-reinvestment-plans"
}

@Article{aprarrftbsp,
  author       = "James~B. Cloonan",
  title        = "{A} Performance Review and Rules Recap for the {B}eginner's {P}ortfolio",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 5,
  pages        = "14--15",
  month        = jun,
  keywords     = "performance, portfolio management, stock selection",
  abstract     = "A strategy based on criteria that have been successful over
    the long term and that is followed religiously should lead to above-average
    results.", 
  location     = "http://www.aaii.com/journal/article/a-performance-review-and-rules-recap-for-the-beginner-s-portfolio"
}

@Article{nlisidpoa,
  author       = "Marie Swick",
  title        = "No-Load International Stock Investing: Direct Purchase of {ADR}s",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 5,
  pages        = "20--21",
  month        = jun,
  keywords     = "american depository receipts, direct purchase",
  abstract     = "Two banks allow investors to buy their first shares of a
    number of foreign stocks that trade on U.S. exchanges in American
    depositary receipts.", 
  location     = "http://www.aaii.com/journal/article/no-load-international-stock-investing-direct-purchase-of-adrs"
}

@Article{tp1yawtmratf,
  author       = "Mark Hulbert",
  title        = "The Past 17 Years and What They May Reveal About the Future",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 5,
  pages        = "31--33",
  month        = jun,
  keywords     = "forecasts, performance",
  abstract     = "The two newsletters that beat the market over the last 17
    years on a risk-adjusted basis are cautious on the market.", 
  location     = "http://www.aaii.com/journal/article/the-past-17-years-and-what-they-may-reveal-about-the-future"
}

@Article{trwagaarp,
  author       = "Maria Crawford Scott",
  title        = "The {R}alph {W}anger Approach:  Growth at a Reasonable Price",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "3--6",
  month        = may,
  keywords     = "small-cap stocks, growth stocks, trends, purchase criteria,
    sell signals",
  abstract     = "Finding growth opportunities in the small-cap arena--Ralph
    Wanger's Approach.", 
  location     = "http://www.aaii.com/journal/article/the-ralph-wanger-approach-growth-at-a-reasonable-price"
}

@Article{chprwyhtmmf,
  author       = "Maria Crawford Scott",
  title        = "Cleaning House: Portfolio Reorganizing When You Have Too Many Mutual Funds",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "7--10",
  month        = may,
  keywords     = "portfolio management, housecleaning",
  abstract     = "How to trim down an overgrown mutual fund portfolio.",
  location     = "http://www.aaii.com/journal/article/cleaning-house-portfolio-reorganizing-when-you-have-too-many-mutual-funds"
}

@Article{taotdiyatiis,
  author       = "James~B. Cloonan",
  title        = "The Advantages of the Do-It-Yourself Approach to Investing in Stocks",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "14--15",
  month        = may,
  keywords     = "returns, portfolio management, stock selection",
  abstract     = "Managing your own stock fund--a review of the approaches and
    their strengths.", 
  location     = "http://www.aaii.com/journal/article/the-advantages-of-the-do-it-yourself-approach-to-investing-in-stocks"
}

@Article{fiiacembf,
  author       = "Albert~J. Fredman",
  title        = "Fixed-Income Investing: Analyzing Closed-End Municipal Bond Funds",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "18--22",
  month        = may,
  keywords     = "closed-end funds, open-end funds, muni bonds, tax equivalent
    yields", 
  abstract     = "Closed-end municipal bond funds--how to analyze a complex
    segment of the closed-end fund universe.", 
  location     = "http://www.aaii.com/journal/article/fixed-income-investing-analyzing-closed-end-municipal-bond-funds"
}

@Article{hmmfsyhiyip,
  author       = "John Markese",
  title        = "How Many Mutual Funds Should You Have in Your Investment Portfolio?",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 3,
  pages        = "2--4",
  month        = apr,
  keywords     = "fund categories, style diversification, portfolio size",
  abstract     = "How many funds do you need in your investment portfolio?",
  location     = "http://www.aaii.com/journal/article/how-many-mutual-funds-should-you-have-in-your-investment-portfolio-"
}

@Article{sfgavbowwows,
  author       = "John Bajkowski",
  title        = "Screening for Growth and Value Based on ``What Works on {W}all {S}treet''",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "5--9",
  month        = apr,
  keywords     = "value strategies, growth strategies, multifactor strategies,
    cornerstones, ",
  abstract     = "Screening stocks based on James O'Shaughnessy's Cornerstone
    growth and value approaches.", 
  location     = "http://www.aaii.com/journal/article/screening-for-growth-and-value-based-on-what-works-on-wall-street-"
}

@Article{nsascsmsfi,
  author       = "James~B. Cloonan",
  title        = "Neglected Stocks and Small Caps Still Make Sense for Individuals",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "12--14",
  month        = apr,
  keywords     = "risk management, return, leverage",
  abstract     = "Recent articles and books have questioned whether the
    concepts underlying Shadow Stocks remain valid. A close look at the
    statistics indicate that they do.",
  location     = "http://www.aaii.com/journal/article/neglected-stocks-and-small-caps-still-make-sense-for-individuals"
}

@Article{aflasoaatss,
  author       = "Mark Hulbert",
  title        = "{A} Fresh Look at Some Old Anomalies: Are They Still Successful?",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 4,
  pages        = "28--30",
  month        = apr,
  keywords     = "small-cap, value, growth",
  abstract     = "Is it time for investors to rethink their commitment to the
    better-known anomalies?", 
  location     = "http://www.aaii.com/journal/article/a-fresh-look-at-some-old-anomalies-are-they-still-successful-"
}

@Article{tlrka,
  author       = "Kaleem Anwar and Muhammad Amir and Ahmad Saeed and Muhammad
    Imran", 
  title        = "The {L}inux Router",
  journal      = lj,
  year         = 2002,
  number       = 100,
  pages        = "121--125",
  month        = aug,
  keywords     = "routing, performance, bandwidth, kernel mods",
  abstract     = "Sure a Linux router is cheaper than a Cisco router, but how
    does it stack up performance-wise?",
  location     = "http://www.linuxjournal.com/article/5826"
}

@Article{sioalsn,
  author       = "Ibrahim Haddad and Marc Blanchet",
  title        = "Supporting {IPv6} on a {L}inux server node",
  journal      = lj,
  year         = 2002,
  number       = 100,
  pages        = "100--107",
  month        = aug,
  keywords     = "kernel support, tcpdump, libpcap",
  abstract     = "These changing times: set up your own IPv6 server and connect
    to the IPv6 world.",
  location     = ""
}

@Article{gbift,
  author       = "David Sugar",
  title        = "{GNU} {B}ayonne is for telephony",
  journal      = lj,
  year         = 2002,
  number       = 100,
  pages        = "58--62",
  month        = aug,
  keywords     = "acs, digital telephony",
  abstract     = "The Bayonne Project makes running telephony software on any
    vendor's card possible.",
  location     = "http://www.linuxjournal.com/article/6077"
}

@Article{esalc,
  author       = "Peter Ryser and Michael Baxter",
  title        = "Embedded System {\` a} la Carte",
  journal      = lj,
  year         = 2002,
  number       = 100,
  pages        = "48--56",
  month        = aug,
  keywords     = "fpga",
  abstract     = "Virtex-II Pro FPGA and MontaVista Linux provide a highly
    flexible and powerful solution for embedded system designers.",
  location     = "http://www.linuxjournal.com/article/6073"
}

@Article{ttl,
  author       = "Greg Kroah-Hartman",
  title        = "The {tty} Layer",
  journal      = lj,
  year         = 2002,
  number       = 100,
  pages        = "40--47",
  month        = aug,
  keywords     = "device drivers, kernel structure, tty",
  abstract     = "In the first of a series of articles on device-driver
    development, we'll start with how the kernel handles the system console and
    serial ports.", 
  location     = "http://www.linuxjournal.com/article/5896"
}

@Article{rypwmpw,
  author       = "Mari Crawford Scott",
  title        = "Rebalancing Your Portfolio When Making Periodic Withdrawals",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 2,
  pages        = "6--9",
  month        = feb,
  keywords     = "portfolio management, rebalancing",
  abstract     = "Keeping your investment portfolio in balance when making
    periodic withdrawals.",
  location     = "http://www.aaii.com/journal/article/rebalancing-your-portfolio-when-making-periodic-withdrawals"
}

@Article{arotqatsm,
  author       = "James~B. Cloonan",
  title        = "{A} Review of the Qualative Approaches to Stock Management",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 2,
  pages        = "20--21",
  month        = feb,
  keywords     = "stock stories, animal spirits, price overreactions",
  abstract     = "Qualitative approaches require investor judgment, and to
    make excess returns, your judgment needs to be more correct than that of
    the overall market.",  
  location     = "http://www.aaii.com/journal/article/a-review-of-the-qualitative-approaches-to-stock-management"
}

@Article{aclammfbca,
  author       = "Albert~J. Fredman",
  title        = "{A} Closer Look at Money Market Funds:  Bank {CD} Alternatives",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 2,
  pages        = "22--27",
  month        = feb,
  keywords     = "derivatives, tax-free portfolios, credit risks, inflation,
    return tracking, yields",
  abstract     = "The Dow Jones industrial average is the most widely followed
    market indicator, and now investement products that feature Dow stocks are
    starting to attract attention.", 
  location     = "http://www.aaii.com/journal/article/a-closer-look-at-funds-that-focus-on-the-dow"
}

@Article{sjatmc,
  author       = "Michael Swaine",
  title        = "{S}un, {J}ava, and the Middle Course",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "16--22",
  month        = aug,
  keywords     = "java",
  location     = "http://www.drdobbs.com/jvm/189401579"
}

@Article{dtzgar,
  author       = "Zvi Gutterman and Avner Rosenan",
  title        = "Device Trails",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "24--30",
  month        = aug,
  keywords     = "plug and play, windows, bluetooth, wi fi, security",
  location     = "http://www.drdobbs.com/security/189401600"
}

@Article{dric,
  author       = "Joe Celko",
  title        = "Discovering Relationships in Context",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "32--36",
  month        = aug,
  keywords     = "forensic computing, visualization",
  location     = "http://www.drdobbs.com/database/189401684"
}

@Article{cjdd,
  author       = "Steve Taylor",
  title        = "Configuring {J2EE} Deployment Descriptions",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "38--43",
  month        = aug,
  keywords     = "ides, parameterizing, spreadsheet",
  location     = "http://www.drdobbs.com/jvm/189401694"
}

@Article{qkpm,
  author       = "Andrew Stellman and Jennifer Greene",
  title        = "Quick-Kill Projecct Management",
  journal      = ddj,
  year         = 2006,
  number       = 287,
  pages        = "44--48",
  month        = aug,
  keywords     = "project management, reviews",
  location     = "http://www.drdobbs.com/architecture-and-design/189401902"
}

@Article{cqijhy,
  author       = "JunHo Yoon and YoonKyu Jang",
  title        = "Code Quality Improvement",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "49--52",
  month        = aug,
  keywords     = "coding standards, code checkers",
  location     = "http://www.drdobbs.com/tools/189401916"
}

@Article{idolpb,
  author       = "Pete Becker",
  title        = "In Defense of Laziness",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "53--56",
  month        = aug,
  keywords     = "software development",
  location     = "http://www.drdobbs.com/cpp/189401941"
}

@Article{btgswa,
  author       = "Scott~W. Ambler",
  title        = "Bridging the Gap",
  journal      = ddj,
  year         = 2006,
  number       = 387,
  pages        = "64--67",
  month        = aug,
  keywords     = "software development, agile methods, project management",
  location     = "http://www.drdobbs.com/architecture-and-design/189401954"
}

@Article{mfshtuasllge,
  author       = "John Markese",
  title        = "Mutual Fund Selection:  How to Use {AAII}'s Low-Load Guide Effectively",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 1,
  pages        = "2--5",
  month        = jan,
  keywords     = "performance, risk, evaluation, portfolio management",
  abstract     = "Evaluating mutual funds without an approach can be
  overwhelming. A guided tour through AAII's 1997 Low-Load Fund Guide data
  page.", 
  location     = "http://www.aaii.com/journal/article/mutual-fund-selection-how-to-use-aaii-s-low-load-guide-effectively"
}

@Article{reyaailovpp,
  author       = "Maria Crawford Scott",
  title        = "Re-Examining Your Asset Allocation in Light of Vested Pension Payments",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 1,
  pages        = "10--11",
  month        = jan,
  keywords     = "asset allocation",
  abstract     = "Expanding the definition of a portfolio to include a vested
    pension can dramatically change one's asset allocation. A case study on how
    to approach an expanded portfolio.", 
  location     = "http://www.aaii.com/journal/article/re-examining-your-asset-allocation-in-light-of-vested-pension-payments"
}

@Article{isaitssp5dr,
  author       = "Robert~T. Kleiman",
  title        = "Index Stocks: An Introduction to {SPDR}s---{S}\&{P} 500 Depositary Receipts",
  journal      = aaiij,
  year         = 1997,
  volume       = 19,
  number       = 1,
  pages        = "23--26",
  month        = jan,
  keywords     = "spdrs, creation units, trading",
  abstract     = "Looking for an index fund that trades like a stock? The S&P
    500 Depositary Receipt is an exchange-traded product that contains features
    of both. An introduction to SPDRs.",
  location     = "http://www.aaii.com/journal/article/index-stocks-an-introduction-to-spdrs-s-p-500-depositary-receipts"
}

@Article{besbf,
  author       = "Jeffrey Lotspiech and Stefan Nusser ad Florian Pestoni",
  title        = "Broadcast Encryption's Bright Future",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "57--63",
  month        = aug,
  keywords     = "drm, broadcast communication, home networks, public key
    cryptography", 
  abstract     = "Broadcast encryption was designed to answer the 
    question--Can two devices, previously unknown to each other, agree upon a
    key if they only have a one-way communication path? They can, and the
    one-way nature of this communication gives the technology its name.  Recent
    advances in broadcast encryption threaten to unseat public key encryption's
    use in certain applications.  To commercialize the technology for media
    content protection, IBM, Intel, Matsushita, and Toshiba developed the
    Content Protection for Recordable Media technology.  Devices that use CPRM
    have already been marketed, including digitalaudio players and video
    recorders, and some flash-memory music players.  The authors' work focuses
    on various aspects of content protection, which they consider to be the
    ideal application for broadcast encryption.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1023789"
}

@Article{chabftm,
  author       = "George Cybenko and Annarita Giani and Paul Thompson",
  title        = "Cognitive Hacking: {A} Battle for the Mind",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "50--56",
  month        = aug,
  keywords     = "social hacking, fraud, misinformation, defacing",
  abstract     = "On 25 August 2000, stockholders were stunned by news that
    server and storage provider Emulex was revising its earnings from a
    per-share gain to a loss, while lowering its reported net earnings from the
    previous quarter as well.  Within minutes, Emulex shares plummeted.  Yet
    none of this news fostered by a hacker's bogus press release was true.The
    Emulex case illustrates the speed, scale, and subtlety with which networked
    information can propagate and how quickly severe consequences can occur.
    This rapid dissemination, which makes such cognitive hacking possible, is
    forcing security researchers to look at yet another class of
    countermeasures a class far different from solutions that seek to secure
    technology and network infrastructure.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1023789"
}

@Article{pisndjr,
  author       = "Peter Gutman",
  title        = "{PKI}: It's Not Dead, Just Resting",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "41--49",
  month        = aug,
  keywords     = "certificates, revocation",
  abstract     = "Like other flexible objects, the public key infrastructure
    sacrifices some utility in trying to be all things to all people.  Mainly,
    PKI's generic, all-purpose identity certificates fall short of what the
    marketplace demands, forcing vendors to develop more economically
    efficient, useful, and imaginative business models.  Thus, we must adapt
    the PKI design to the real world rather than trying to constrain the real
    world to match the PKI.  A variety of alternative approaches, ranging from
    simple workarounds to designing the application to sidestep
    PKI'sshortcomings entirely, can help solve the problems inherent in the
    standard X.509 model.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1023787"
}

@Article{jhnastpc,
  author       = "Rahul Gupta and Sumeet Talwar and Dharma~P. Agrawal",
  title        = "Jini Home Networking: {A} Step toward Pervasive Computing",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "34--40",
  month        = aug,
  keywords     = "peer-to-peer networking, federation",
  abstract     = "Two trends are moving us closer to pervasive computing.
    First, recent advances in technology fuel the market for intelligent
    devices that can interact with each other anytime, worldwide.  Second,
    decreasing processor costsand size let engineers endow thesedevices with
    application-specific processingpower.  Home networks represent a
    significant step toward realizing the pervasive computing vision.  Because
    a home network allows appliances to communicate witheach other, it needs a
    technology that can seamlessly integrate assorted devices intoa monolithic
    communications network.  Jini accomplishes this by integrating
    distributedcomputing, network-based services, and reliable smart devices in
    a scalable network without administrative overhead.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1023787"
}

@Article{ligits,
  author       = "Mary Lacity",
  title        = "Lessons in Global Information Technology Sourcing",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "26--33",
  month        = aug,
  keywords     = "it sourcing, market evaluations, time and material contracts,
    exchange-based contracts, netsourcing, joint ventures, bidding, core
    competencies, ",
  abstract     = "Research firms estimate the current global outsourcing
    market to be as high as US$500 billion, with the number of external IT
    outsourcing suppliers swelling into the thousands.  Most notable, however,
    is how well customers have learned to exploit the IT services market.  The
    author and her colleagues studiedsourcing practices in 543 large and small
    organizations worldwide, measuringactual outcomes against expected
    out-comes to draw conclusions about practices associated with success and
    failure.  The lessons from this IT sourcing research should help both
    customers and suppliers avoid sourcing pitfalls, allowing them to establish
    contracts and develop relationship management capabilities that will
    benefit both parties.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1023785"
}

@Article{itts,
  author       = "Bill Arbaugh",
  title        = "Improving the {TCPA} Specification",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "77-79",
  month        = aug,
  keywords     = "trusted computing, privacy",
  abstract     = "The Trusted Computing Platform Alliance (TCPA) specification
    is a new computing platform for the next century that will provide for
    improved trust in the PC platform.  Improving information security is an
    important and timely goal, but not at the cost of further weakening fair
    use doctrine, encouraging anticompetitive behavior, or eliminating privacy.
    Unfortunately, the current specification does not meet this standard.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1023792"
}

@Article{wb3msanr,
  author       = "Panagiotis Demestichas and Louisa Papadopoulou and Vera
    Stavroulaki and Michael Theologou and Guillaume Vivier and Georges Martinez
    and Fabio Galliano",
  title        = "Wireless Beyond {3G}: Managing Services and Network Resources",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "80--82",
  month        = aug,
  keywords     = "wireless, federating, network management",
  abstract     = "Wireless beyond 3G is a new concept that envisions cellular,
    BFWA, and DVB systems cooperating in a composite radio infrastructure.  In
    this scheme, instead of rejecting users or degrading their quality of
    service levels, a network provider can direct them to an alternate radio
    technology that meets certain environmental, cost, and QoS criteria.  To
    achieve such a system requires upgrading service and network resource
    management (SNRM).  We present work areas for a new SNRM approach that
    comprises the Universal Mobile Telecommunications System (UMTS),
    high-performance wireless local area network (HiperLAN 2) technology, and
    terrestrial DVB (DVB-T) systems.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1023793"
}

@Article{hgsns,
  author       = "Dean Chang",
  title        = "Haptics: Gaming's New Sensation",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "84--86",
  month        = aug,
  keywords     = "gaming, haptics, user experience",
  abstract     = "Haptics technology can simulate tactile and kinesthetic
    sensations so that computer interfaces not only look but also feel - in the
    literal sense of the word - like the interfaces we are accustomed to using
    in the real world.  Although haptics in PC gaming began by focusing on
    kinesthetics, while haptics in console gaming began by focusing on
    vibrotactile effects, game players and market pressures are driving the
    wide adoption of both forms by both sectors.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1023795"
}

@Article{taops,
  author       = "D.~M. Orrick",
  title        = "Toward adequate online privacy safeguards",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 8,
  pages        = "90--92",
  month        = aug,
  keywords     = "privacy",
  abstract     = "The author is concerned with the disclosure of information
    that might make a student vulnerable to everything from simple spam to
    criminal harassment or worse.  Computing professionals working in a
    university environment have an opportunity to ensure that universities
    respect the personal privacy of students.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1023797"
}

@Article{mlaooitfracbd,
  author       = "Yannis Smaragdakis and Don Batory",
  title        = "Mixin Layers:  An Object-Oriented Implementation Technique for Refinements and Collaboration-Based Designs",
  journal      = tosem,
  year         = 2002,
  volume       = 11,
  number       = 2,
  pages        = "215--255",
  month        = apr,
  keywords     = "collaboration-based design, abstract classes, component-based
    software, product-line architecture",
  abstract     = "A refinement is a functionality addition to a software
    project that can affect multiple dispersed implementation entities
    (functions, classes, etc.).  In this paper, we examine large-scale
    refinements in terms of a fundamental object-oriented technique called
    collaboration-based design.  We explain how collaborations can be expressed
    in existing programming languages or can be supported with new language
    constructs (which we have implemented as extensions to the Java language).
    We present a specific expression of large-scale refinements called mixin
    layers, and demonstrate how it overcomes the scalability difficulties that
    plagued prior work.  We also show how we used mixin layers as the primary
    implementation technique for building an extensible Java compiler, JTS.", 
  location     = "http://people.cs.umass.edu/~yannis/tosem01.pdf",
  location     = "http://dx.doi.org/10.1145/505145.505148"
}

@Article{adomftjs,
  author       = "Ann Wollrath and Roger Riggs and Jim Waldo",
  title        = "{A} Distributed Object Model for the {J}ava System",
  journal      = cs,
  year         = 1996,
  volume       = 9,
  number       = 4,
  pages        = "265--290",
  month        = "Fall",
  keywords     = "remote method invocation, distributed computing, remote
    objects, proxies", 
  abstract     = "We show a distributed object model for the Java 1 System
    (hereafter referred to simply as Java) that retains as much of the
    semantics of the Java object model as possible, and only includes
    differences where they make sense for distributed objects.  The distributed
    object system is simple, in that a) distributed objects are easy to use and
    to implement, and b) the system itself is easily extensible and
    maintainable.  We have designed such a model and implemented a system that
    supports remote method invocation (RMI) for distributed objects in Java.
    This system combines aspects of both the Modula-3 Network Objects system
    and Spring's subcontract and includes some novel features.  To achieve its
    goal of seamless integration in the language, the system exploits the use
    of pickling to transmit arguments and return values and also exploits
    unique features of Java in order to dynamically load stub code to clients.
    The final system will include distributed references.", 
  location     = "http://pdos.csail.mit.edu/6.824-2009/papers/waldo-rmi.pdf"
}

@Article{ftfotmcahmbbs,
  author       = "John Markese",
  title        = "Funds That Focus on the Mid-Caps: {A} Happy Medium Between Big \& Small",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 10,
  pages        = "10--12",
  month        = nov,
  keywords     = "mutual funds, size",
  abstract     = "Funds that focus on medium-capitalization stocks are coming
    in vogue, but without a consensus as to what constitutes mid-size. A look
    at mid-cap funds.", 
  location     = "http://www.aaii.com/journal/article/funds-that-focus-on-the-mid-caps-a-happy-medium-between-big-small"
}

@Article{gsdaipfgl,
  author       = "Maria Crawford Scott",
  title        = "Getting Started: Developing an Investment Plan From Ground Level",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 10,
  pages        = "13--15",
  month        = nov,
  keywords     = "investment strategies, asset allocation",
  abstract     = "Younger investors building an investment portfolio from
    scratch face the limitations of their meager savings. A case study gives
    one example of where to begin.", 
  location     = "http://www.aaii.com/journal/article/getting-started-developing-an-investment-plan-from-ground-level"
}

@Article{abcvishqoofs,
  author       = "Maria Crawford Scott",
  title        = "{A} Blue-Chip Value Investor: Seeking High-Quality, Out-of-Favor Stocks",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 10,
  pages        = "16--19",
  month        = nov,
  keywords     = "blue chips, value investing, dividend yields, sell signals",
  abstract     = "Dividends matter: A look at Geraldine Weiss' value approach
    to investing in the blue chips.", 
  location     = "http://www.aaii.com/journal/article/a-blue-chip-value-investor-seeking-high-quality-out-of-favor-stocks"
}

@Article{qmawrwwasp,
  author       = "James~B. Cloonan",
  title        = "Quantitative Measures and What Really Works Within a Stock Portfolio",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 10,
  pages        = "22--24",
  month        = nov,
  keywords     = "book value, cash flows, profit margins, dividends",
  abstract     = "The good news is that a disciplined investor can use a
    combination of criteria to beat 'the market.' The bad news is, the
    outperformance is not going to be dramatic.", 
  location     = "http://www.aaii.com/journal/article/quantitative-measures-and-what-really-works-within-a-stock-portfolio"
}

@Article{taswtbmalatr,
  author       = "Mark Hulbert",
  title        = "Timing and Selection Within the Bond Market: {A} Look at the Record",
  journal      = aaiij,
  year         = 1996,
  volume       = 18,
  number       = 10,
  pages        = "28--30",
  month        = nov,
  keywords     = "market timing, bond funds, asset allocation",
  abstract     = "How have bond fund advisers performed? An analysis of market
    timing and mutual fund selection among bond fund newsletters.",
  location     = "http://www.aaii.com/journal/article/timing-and-selection-within-the-bond-market-a-look-at-the-record"
}

@Article{hathpsf,
  author       = "John Markese",
  title        = "Health and Technology:  High-Powered Sector Funds",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 10,
  pages        = "3--7",
  month        = nov,
  keywords     = "health, technology, sector funds",
  abstract     = "Given the complexities of companies in the health and
    technology fields, funds focusing on these sectors provide specialized
    management and diversification for investors interested in commitments in
    these areas.", 
  location     = "http://www.aaii.com/journal/article/health-and-technology-high-powered-sector-funds"
}

@Article{aissuiyp,
  author       = "Maria Crawford Scott",
  title        = "Are International Stocks Still Useful in Your Portfolio?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 10,
  pages        = "8--10",
  month        = nov,
  keywords     = "diversification",
  abstract     = "A long-term look at the performance record indicates that the
    benefits of international diversification are still evident. In the long
    run, a country's performance will be based on its economic growth and
    productivity.", 
  location     = "http://www.aaii.com/journal/article/are-international-stocks-still-useful-in-your-portfolio-"
}

@Article{tctosis,
  author       = "Maria Crawford Scott",
  title        = "The Common Traits of Successful Investment Strategies",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 10,
  pages        = "11--15",
  month        = nov,
  keywords     = "valuations, earnings, dividends, sell signals",
  abstract     = "Although there are many investment approaches, they share
    common traits--in particular seeking quality companies with good growth
    prospects that can be purchased at a reasonable price.", 
  location     = "http://www.aaii.com/journal/article/the-common-traits-of-successful-investment-strategies"
}

@Article{icosboeyc,
  author       = "James B. Cloonan",
  title        = "Increasing Chance of Success Based on Election-Year Cycle",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 10,
  pages        = "16--17",
  month        = nov,
  keywords     = "data analysis, election-year bounce",
  location     = "http://www.aaii.com/journal/article/increasing-chance-of-success-based-on-election-year-cycle"
}

@Article{iapavoa,
  author       = "Mark Hulbert",
  title        = "Investment Approaches: Picking a Value-Oriented Adviser",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 10,
  pages        = "23--25",
  month        = nov,
  keywords     = "value investing, style drift, size, performance",
  abstract     = "Value stocks have outperformed growth stocks over the long
    term, but putting the value approach theory into practice is easier said
    than done. How to choose a value adviser.", 
  location     = "http://www.aaii.com/journal/article/investment-approaches-picking-a-value-oriented-adviser"
}

@Article{mombalats,
  author       = "John Bajkowski",
  title        = "Measures of Market Breadth:  {A} Look at Trading Statistics",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 9,
  pages        = "2--5",
  month        = oct,
  keywords     = "issues traded, volume, advance/decline line, market
    statistics",
  abstract     = " Market breadth statistics attempt to measure how widely the
    full range of stocks are participating in stock market movement, and are
    more informative about market behavior than simply following changes in an 
    index.", 
  location     = "http://www.aaii.com/journal/article/measures-of-market-breadth-a-look-at-trading-statistics"
}

@Article{tsdkwtwa,
  author       = "Albert~J. Fredman",
  title        = "The Sell Decision: Knowing When to Walk Away",
  journal      = aaaiij,
  year         = 1998,
  volume       = 20,
  number       = 9,
  pages        = "6--11",
  month        = oct,
  keywords     = "performance, sell signals, tax considerations, closed-end
    funds, risk creep",
  abstract     = " Impulsively jumping in and out of your fund holdings is not
    a sensible approach, but neither should you assume you can simply hold for
    a lifetime. When to consider selling a fund.", 
  location     = "http://www.aaii.com/journal/article/the-sell-decision-knowing-when-to-walk-away"
}

@Article{caybditusm,
  author       = "Market Crawford Scott",
  title        = "Covering All Your Bases: Diversifying in the {U}.{S}. Markets",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 9,
  pages        = "12--14",
  month        = oct,
  keywords     = "market segments, diversification, asset allocation",
  abstract     = " Firms of different market capitalizations behave differently
    and their complementary behavior can significantly reduce risk for
    investors who diversify.", 
  location     = "http://www.aaii.com/journal/article/covering-all-your-bases-diversifying-in-the-u-s-markets"
}

@Article{vgsrtnf,
  author       = "Jeremy Siegel",
  title        = "Valuing Growth Stocks: Revisiting the {N}ifty {F}ifty",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 9,
  pages        = "20--24",
  month        = oct,
  keywords     = "nifty fifty, returns, eps, p/3, growth",
  abstract     = "The lofty levels reached by the Nifty Fifty in the early
    1970s is often held up as an example of unwarranted speculation. But
    investors were right to predict that the growth of these firms would
    eventually jusfity their prices.",
  location     = "http://www.aaii.com/journal/article/valuing-growth-stocks-revisiting-the-nifty-fifty"
}

@Article{scsdbdistr,
  author       = "James~B. Cloonan",
  title        = "Small-Cap Stocks Dominate, But Diversification is Still the Rule",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 9,
  pages        = "25--26",
  month        = oct,
  keywords     = "small caps, category performance",
  abstract     = {Except for the last few years, the statistics over the long
    term favor small-cap stocks. But as the saying goes, "What have you done
    for me lately?"},
  location     = "http://www.aaii.com/journal/article/small-cap-stocks-dominate-but-diversification-is-still-the-rule"
}

@Article{cbadpac,
  author       = "Maria Crawford Scott",
  title        = "Cash Benefits: {A} Dual-Purpose Asset Class",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 8,
  pages        = "12--14",
  month        = sep,
  keywords     = "spending, volatility",
  abstract     = "Cash may seem boring to investors concentrating on long-term
    return attributes, but it plays two important roles in any investment
    portfolio--providing liquidity and tempering downside risk.",
  location     = "http://www.aaii.com/journal/article/cash-benefits-a-dual-purpose-asset-class"
}

@Article{aiotiafnblot,
  author       = "James~B. Cloonan",
  title        = "An {IMO} on the {I}nternet: {A} Few Nuggets, But Lots of Trash",		  
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 8,
  pages        = "28--29",
  month        = sep,
  keywords     = "the internet",
  abstract     = "A perusal of Internet message boards on stock investing
    reveals that only a small percentage contain postings with sophisticated
    insights into companies.",
  location     = "http://www.aaii.com/journal/article/an-imo-on-the-internet-a-few-nuggets-but-lots-of-trash"
}

@Article{nvfwatbp,
  author       = "Mark Hulbert",
  title        = "Newsletters vs. Funds: Which are the Better Performers?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 8,
  pages        = "30--32",
  month        = sep,
  keywords     = "statistics, rankings, hysteresis",
  abstract     = "Newsletter performance: How winners and losers in the
  newsletter arena stock up against those of the mutual fund industry.",
  location     = "http://www.aaii.com/journal/article/newsletters-vs-funds-which-are-the-better-performers-"
}

@Article{esfsyma,
  author       = "John Markese",
  title        = "European Stock Funds:  Sending Your Money Abroad",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 7,
  pages        = "3--5",
  month        = aug,
  keywords     = "correlation, diversity, currency risk",
  abstract     = " With the economic union near and restructuring and
    privatizations in progress, Europe seems alluring. But European stock funds
    differ, and the actively managed funds have placed both stock and country
    bets.", 
  location     = "http://www.aaii.com/journal/article/european-stock-funds-sending-your-money-abroad"
}

@Article{cotdotds,
  author       = "John Bajkowski",
  title        = "Characteristics of the {D}ogs of the {D}ow Stocks",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 7,
  pages        = "6--9",
  month        = aug,
  keywords     = "dividend valuations, djia, earnings strength",
  abstract     = "The Dogs of the Dow approach takes advantage of the long-term
    positive returns associated with the market, and adds a contrarian bonus by
    focusing on only the highest-yielding stocks.",
  location     = "http://www.aaii.com/journal/article/characteristics-of-the-dogs-of-the-dow-stocks"
}

@Article{hmddypn,
  author       = "Maria Crawford Scott",
  title        = "How Much Diversification Does Your Portfolio Need?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 7,
  pages        = "10--13",
  month        = aug,
  keywords     = "gold, precious metals, real estate, commodities, hedging,
    asset allocations, diversity",
  abstract     = "Precious metals, real estate and commodities are sometimes
    suggested as useful additions to your portfolio. Do they bring more
    diversification? And how practical is investment in them?", 
  location     = "http://www.aaii.com/journal/article/how-much-diversification-does-your-portfolio-need-"
}

@Article{dvapavfs,
  author       = "Stanley Block",
  title        = "Do Value-Added Programs Add Value for Shareholders?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 7,
  pages        = "18--23",
  month        = aug,
  keywords     = "management shamanism, economic value added, accounting data,
    compensation, analysis",
  abstract     = "One method firms use to focus on shareholder interests is
    through EVA programs--measuring economic value added. What these programs
    are and how much they actually impact shareholder value.", 
  location     = "http://www.aaii.com/journal/article/do-value-added-programs-add-value-for-shareholders-"
}

@Article{bcvitdootdo,
  author       = "Maria Crawford Scott",
  title        = "Blue-Chip Value Investing: The {D}ogs of the {D}ow",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 6,
  pages        = "3--6",
  month        = jul,
  keywords     = "value investing, portfolio turnover, djia",
  abstract     = "The purely mechanical nature of the Dow Dogs approach forces
    strict investor discipline and requires no investment decision-making
    expertise.", 
  location     = "http://www.aaii.com/journal/article/blue-chip-value-investing-the-dogs-of-the-dow"
}

@Article{oacecf,
  author       = "Albert~J. Fredman",
  title        = "Open- and Closed-End Convertible Funds",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 6,
  pages        = "7--12",
  month        = jul,
  keywords     = "convertibles bond, preferred stock, price supports, 
    discounts", 
  abstract     = "Mutual funds that invest in convertibles are similar to
    balanced funds, but they tend to hold securities of smaller firms.",
  location     = "http://www.aaii.com/journal/article/open-and-closed-end-convertible-funds"
}

@Article{uialavs,
  author       = "James~H. Gilkeson",
  title        = "Unusual Investments: {A} Look at Viatical Settlements",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 7,
  pages        = "17--21",
  month        = jul,
  keywords     = "aids, insurance",
  abstract     = "Viatical settlements--investments in the life insurance
    policies of the terminally ill--have received considerable publicity
    because of high potential returns, but they are complex and difficult to
    analyze.", 
  location     = "http://www.aaii.com/journal/article/unusual-investments-a-look-at-viatical-settlements"
}

@Article{swocfiihtss,
  author       = "James~B. Cloonan",
  title        = "Some Words of Caution for Investors in High-Tech Speculative Stocks",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 7,
  pages        = "26--27",
  month        = jul,
  keywords     = "variable convertible preferred stock, shorting, venture
    capitalists",
  abstract     = "A lack of funding prompts some developmental-stage companies
    to turn to variable convertible preferred stock issues, with a negative
    impact beyond what many investors would normally expect.",
  location     = "http://www.aaii.com/journal/article/some-words-of-caution-for-investors-in-high-tech-speculative-stocks"
}

@Article{wtlfitnmfp,
  author       = "John Markese",
  title        = "What to Look for in the New Mutual Fund Profile",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 5,
  pages        = "2--5",
  month        = jun,
  keywords     = "investment objectives, investment strategy, investment risk,
  fees, share purchase, selling shares, fund distirbution, services.",
  abstract     = "Starting June 1998, mutual funds will be allowed to offer
    prospective investors a new source of information--the fund profile. A look
    at the points covered and what the profile can and can´t tell you.", 
  location     = "http://www.aaii.com/journal/article/what-to-look-for-in-the-new-mutual-fund-profile"
}

@Article{cofwdrp,
  author       = "John Bajkowski",
  title        = "Characteristics of Firms with Dividend Reinvestment Plans",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 5,
  pages        = "6--8",
  month        = jun,
  keywords     = "dividends, dividend reinvestment",
  abstract     = "Common traits of firms in the 1998 dividend reinvestment
    guide, and how to build a screen based on DRPs.", 
  location     = "http://www.aaii.com/journal/article/characteristics-of-firms-with-dividend-reinvestment-plans"
}

@Article{rldyiiaboab,
  author       = "H.~Bradlee Perry",
  title        = "Record Low Dividend Yields: Is It a Bane or a Blessing?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 5,
  pages        = "23--26",
  month        = jun,
  keywords     = "stock valuations, dividend yields, payout ratios, ",
  abstract     = "Skyrocketing stock valuations and declining payout ratios
    have resulted in the lowest dividend yields in decades. The news for
    investors--mostly good.", 
  location     = "http://www.aaii.com/journal/article/record-low-dividend-yields-is-it-a-bane-or-a-blessing-"
}

@Article{wyrhyrhoayn,
  author       = "Mark Hulbert",
  title        = "When You're Hot, Your're Hot! Or Are You Not?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 5,
  pages        = "32--34",
  month        = jun,
  keywords     = "hot hands, correlation",
  abstract     = "track records, momentum",
  location     = "http://www.aaii.com/journal/article/when-you-re-hot-your-re-hot-or-are-you-not-"
}

@Article{sscysam,
  author       = "Maria Crawford Scott",
  title        = "Scary Scenarios: Can You Survive a Meltdown?",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 5,
  pages        = "10--12",
  month        = jun,
  keywords     = "disaster, preparation",
  abstract     = "No matter what the environment, someone is always predicting
    disaster. The question to address is: What´s the real risk I´m  facing, and
    what´s the best way to reduce it?", 
  location     = "http://www.aaii.com/journal/article/scary-scenarios-can-you-survive-a-meltdown-"
}

@Article{chjhlj,
  author       = "Joey Hess",
  title        = "{CVS} homedir",
  journal      = lj,
  year         = 2002,
  number       = 101,
  pages        = "78--81",
  month        = sep,
  keywords     = "source code control, version control, cvs",
  location     = "http://www.linuxjournal.com/article/5976"
}

@Article{aclaftfotdo,
  author       = "Albert~J. Fredman",
  title        = "{A} Closer Look at Funds That Focus on the {{D}}ow",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 4,
  pages        = "3--7",
  month        = may,
  keywords     = "dow 30, indexes, diamonds, pricing, trading, dogs, mutual
    funds",
  abstract     = "The Dow Jones industrial average is the most widely followed
    market indicator, and now investement products that feature Dow stocks are
    starting to attract attention.",
  location     = "http://www.aaii.com/journal/article/a-closer-look-at-funds-that-focus-on-the-dow"
}

@Article{rertuwcs,
  author       = "Maria Crawford Scott",
  title        = "Re-Examining Risk Tolerance Using Worst-Case Scenarios",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 4,
  pages        = "10--12",
  month        = may,
  keywords     = "scenarios, worst-case analysis",
  abstract     = "Major bull markets can cause asset allocation strategies to
    stray and investors to become overly complacent. Seeing how your portfolio
    would fare in the worst bear market.",
  location     = "http://www.aaii.com/journal/article/re-examining-risk-tolerance-using-worst-case-scenarios"
}

@Article{iittmma,
  author       = "Maria Crawford Scott",
  title        = "Investing in Technology: The {M}ichael {M}urphy Approach",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 4,
  pages        = "13--16",
  month        = may,
  keywords     = "technology sector, growth-flow model, risk, portfolio
    analysis, sell signals",
  abstract     = "Regarding technology as the growth driver of the
    U.S. economy, Murphy seeks to identify firms that are most likely to be the
    future leaders and buys when they are undervalued relative to their growth
    potential.",
  location     = "http://www.aaii.com/journal/article/investing-in-technology-the-michael-murphy-approach"
}

@Article{wtlfiasrp,
  author       = "David~R. Fried",
  title        = "What to Look for in a Stock Repurchase Program",
  journal      = aaiij,
  year         = 1998,
  volume       = 20,
  number       = 4,
  pages        = "21--24",
  month        = may,
  keywords     = "buybacks",
  abstract     = "Stock buybacks can be extremely beneficial to shareholders,
    but they have their subtleties: Companies don´t always follow through on
    announcements, and firms have different motivations for repurchasing
    shares.",
  location     = "http://www.aaii.com/journal/article/what-to-look-for-in-a-stock-repurchase-program"
}

@Article{wdstms,
  author       = "Michael Swaine",
  title        = "Web Developer Survival Tips",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 9,
  pages        = "16--20",
  month        = sep,
  keywords     = "power management, google",
  location     = "http://www.drdobbs.com/web-development/191601618"
}

@Article{snebt,
  author       = "Eric Bergman-Terrell",
  title        = "Synchronize Now!",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 9,
  pages        = "22--29",
  month        = sep,
  keywords     = ".net, amazon s3, ftp, data transfer",
  location     = "http://www.drdobbs.com/database/synchronize-now/191601621"
}

@Article{mijo,
  author       = "Oliver Goldman",
  title        = "Multithreading in {Java} \& {OSGi}",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 9,
  pages        = "30--37",
  month        = sep,
  keywords     = "multi-process programming, threads, interrupts,
    coordination",
  location     = "http://www.drdobbs.com/jvm/multithreading-java-osgi/191601642"
}

@Article{teup,
  author       = "Ivar Jacobson and Pan Wei Ng and Ian Spence",
  title        = "The Essential {Unified Process}",
  journal      = ddj,
  year         = 206,
  volume       = 31,
  number       = 9,
  pages        = "40--45",
  month        = sep,
  keywords     = "unified process, use cases, software development",
  location     = "http://www.drdobbs.com/architecture-and-design/191601687"
}

@Article{acaac,
  author       = "Andrew Colin",
  title        = "Ant Colony Algorithms",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 9,
  pages        = "46--51",
  month        = sep,
  keywords     = "emergent behavior, tsp, optimization problems",
  location     = "http://www.drdobbs.com/parallel/191800178"
}

@Article{mecr,
  author       = "Guy Peleg",
  title        = "Mandatory Error Codes Revisited",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 9,
  pages        = "53--56",
  month        = sep,
  keywords     = "c++, frameworks",
  location     = "http://www.drdobbs.com/cpp/191601612"
}

@Article{jtsatp,
  author       = "Neville Holmes",
  title        = "Jobs, Trades, Skills, and the Profession",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "102--104",
  month        = sep,
  keywords     = "professional responsibility, professions",
  abstract     = "Is the reputed shortage of IT skills a political scam or is 
    the computing profession itself at fault? The author considers IT
    professional responsibility and training issues.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1033038"
}

@Article{wsach,
  author       = "Clay Shirky",
  title        = "Web Services and Context Horizons",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "98--100",
  month        = sep,
  keywords     = "networks, computer, context horizons, trust horizons,
  semantic horizons, coordination horizons",
  abstract     = "Considers how Web services require defining a new meaning
    for local, in which different kinds of applications operate within
    different network horizons.  Understanding these context horizons, and
    creating the tools and techniques for managing them, are essential to
    achieving an Internet-scale operating system.  The paper discusses three of
    the most important: trust horizons, semantic horizons, and coordination
    horizons.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033037"
}

@Article{wwsl ,
  author       = "Wayne Wolf",
  title        = "Whither {W}arhol's Law?",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "96--97",
  month        = sep,
  keywords     = "networks effects, tools, i/o",
  abstract     = "The article discusses a law concocted by the author:
    Warhol's Law of Computer Systems Architecture. This law stated that every
    computer architecture would be the price-performance leader for 15 minutes.
    The author was thinking mainly of workstation CPUs, but he believed the
    embedded CPU market would follow suit.  Embedded systems provide an ideal
    forum for CPU competition.  A lot of people seemed to want to design CPUs,
    so the author reasoned that no end of new competitors would appear to
    introduce new features and drive down prices.  It hasn't worked out that
    way, however.  The high-end market has several players, but not the
    profusion expected a few years go.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033036"
}

@Article{aesi ,
  author       = "Abdelsalam ``Solom'' Heddaya",
  title        = "An Economically Scalable {I}nternet",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "93--95",
  month        = sep,
  keywords     = "quality of experience, quality of service, supercomputer",
  abstract     = "Over the past decade, many observers have claimed that the 
    Internet brings the information revolution's components together in a way
    that will rival the industrial revolution's effects on human productivity
    and quality of life.  The paper discusses an economically scalable
    Internet, including bandwidth resources, quality of service, users' quality
    of experience, scalability and multicast-enabled distribution.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033035"
}

@Article{mbsfdmacp ,
  author       = "Jiannong Cao and Xinyu Feng and Jian Lu and Sajal~K. Das",
  title        = "Mailbox-Based Scheme for Designing Mobile Agent Communication Protocols",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "54--60",
  month        = sep,
  keywords     = "location transparency, mailbox, home server protocols",
  abstract     = "In various situations, mobile agents at different hosts must
    cooperate with one another by sharing information and making decisions
    collectively.  To ensure effective interagent communication, communication
    protocols must track target agent locations and deliver messages
    reliably.Researchers have proposed a wide range of schemes for agent
    tracking and reliable message delivery.  However, each scheme has its own
    assumptions, design goals, and methodology.  As a result, no uniform or
    structured methods exist for characterizing current protocols, making it
    difficult to evaluate their relative effectiveness and performance.The
    authors propose a mailbox-based scheme for designing mobile agent
    communication protocols.  This scheme assigns each agent a mailbox to
    buffer messages, but decouples the agent and mailbox to let them reside at
    different hosts and migrate separately.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033028"
}

@Article{scaes ,
  author       = "Wayne Wolf and Burak Ozer and Tiehan Lv",
  title        = "Smart Cameras as Embedded Systems",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "48--53",
  month        = sep,
  keywords     = "image processing, motion detection, gesture recognition",
  abstract     = "Recent technological advances are enabling a new generation
    of smart cameras that represent a quantum leap in sophistication.  While
    today's digital cameras capture images, smart cameras capture high-level
    descriptions of the scene and analyze what they see.  These devices could
    support a wide variety of applications including human and animal
    detection, surveillance, motion analysis, and facial identification.  Video
    processing has an insatiable demand for real-time performance.  Smart
    cameras leverage very large-scale integration to meet this need in a
    low-cost, low-power system with substantial memory.  Moving well beyond
    pixel processing and compression, these VLSI systems run a wide range of
    algorithms to extract meaning from streaming video.  Recently, Princeton
    University researchers developed a first-generation smart camera system
    that can detect people and analyze their movement in real time.  Because
    they push the design space in so many dimensions, these smart cameras are a
    leading-edge application for embedded system research.Mailbox-Based Scheme
    for Designing Mobile Agent Communication Protocols", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033027"
}

@Article{padcc ,
  author       = "Vinod Kathail and Shail Aditya and Robert Schreiber and
    B.~Ramakrishna Rau and Darren~C. Cronquist and Mukund Sivaraman",
  title        = "{PICO}: Automatically Designing Custom Computers",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "39--47",
  month        = sep,
  keywords     = "hierarchical design, system composition, vliw compiler
    design",
  abstract     = "The PICO (program in, chip out) project is a long-range HP
    Labs research effort that aims to automate the design of optimized,
    application-specific computing systemsýthus enabling the rapid and
    cost-effective design of custom chips when no adequately specialized,
    off-the-shelf design is available.  PICO research takes a systematic
    approach to the hierarchical design of complex systems and advances
    technologies for automatically designing custom nonprogrammable
    accelerators and VLIW processors.  While skeptics often assume that
    automated design must emulate human designers who invent newsolutions to
    problems, PICO's approach is to automatically pick the most suitable
    designs from a well-engineered space of designs.  Such automation of
    embedded computer design promises an era of yetmore growth in the number
    and variety of innovative smart products by lowering the barriers of design
    time, designer availability, and design cost.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033026"
}

@Article{tiobmis ,
  author       = "Chuck Walrad and Darrel Strom",
  title        = "The Importance of Branching Models in {SCM}",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "31--38",
  month        = sep,
  keywords     = "software control method, branching model, branch by release,
    slipstream development, parallel development",
  abstract     = "To improve software quality, you must first understand your
    software.  If you do not understand your code base, your odds of updating
    it without breaking something are poor.  Often, a fundamental
    misunderstanding of software configuration management (SCM) as it applies
    to real-world application development is at fault.  Branching is integral
    to version management, software build correctness, and release management.
    Good decisions about when and why to branch can make it much easier for
    developers and release engineers to coordinate software product changes.
    The right branching strategy makes it easier to deliver the right code,
    re-create past releases, and--if necessary--roll back to a previous
    release.  Adopting the right SCM branching model facilitates rapid
    development, increases overall product quality and process efficiency,
    reduces the incidence of software failures, and improves organizational
    performance.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033025"
}

@Article{mfswcgi ,
  author       = "Oliver Bimber and Stephen~M. Gatesy and Lawrence~M. Witmer
    and Ramesh Raskar and L.~Miguel Encarna\c{c}{\~ a}o",
  title        = "Merging Fossil Specimens with Computer-Generated Information",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 9,
  pages        = "35--30",
  month        = sep,
  keywords     = "augmented paleontology, soft-tissue reconstruction, motion
    tracking",
  abstract     = "While dinosaur fossils reveal much, they keep us guessing
    about the original organisms' color, sound, and behavior.  For several
    years, modern paleontologists have used 3D computer graphics to help
    reconstruct these pieces of the past.  Augmented reality leverages this
    technology to provide an interface that enhances the real world with
    synthetic supplements.  Paleontologists can use AR to present virtual data
    directly within a real, 3D environment rather than on a flat monitor.  This
    technology's immersiveness can give paleontologists new insights into their
    research and communicate the results to museum visitors in an exciting and
    effective way.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1033024"
}

@Article{tesoc,
  author       = "Charles Anthony Richard Hoare",
  title        = "The Emperor's Old Clothes",
  journal      = cacm,
  year         = 1981,
  volume       = 24,
  number       = 2,
  pages        = "75--83",
  month        = feb,
  keywords     = "language design, complexity",
  location     = "http://dx.doi.org/10.1145/358549.358561"
}

@Article{hmayrpfymf,
  author       = "John Markese",
  title        = "How Much Are You Really Paying For Your Mutual Funds?",
  journal      = aaiij,
  year         = 1999,
  volume       = 21,
  number       = 2,
  pages        = "2--5",
  month        = feb,
  keywords     = "fund operating expenses, expense ratios, loads",
  abstract     = "Fund loads and expenses decrease your investment return
    dollar-for-dollar. Looking forward, the costs are predictable, while
    returns are not. It pays to pay attention to how much you pay.",
  location     = "http://www.aaii.com/journal/article/how-much-are-you-really-paying-for-your-mutual-funds-"
}

@Article{asitcorv,
  author       = "Marcus~W. Robins",
  title        = "Analyzing Stock Investments: The Concept of Relative Value",
  journal      = aaiij,
  year         = 1999,
  volume       = 21,
  number       = 2,
  pages        = "6--11",
  month        = feb,
  keywords     = "value curve, analysis",
  abstract     = "All the valuation yardsticks on the relative value curve
    represent valid investment approaches. However, each technique as you
    progress along the curve tends to pose a greater degree of risk, as
    measured by price volatility.",
  location     = "http://www.aaii.com/journal/article/analyzing-stock-investments-the-concept-of-relative-value"
}

@Article{ifiialire,
  author       = "Robert~D. Siefert",
  title        = "Investing for Income in a Low Interest Rate Environment",
  journal      = aaiij,
  year         = 1999,
  volume       = 21,
  number       = 2,
  pages        = "26--30",
  month        = feb,
  keywords     = "income investing, interest rate, risk assessment, portfolio
    allocations,", 
  abstract     = "The dilemma for retirees: How do you invest for a desired
    rate of return in excess of that which is attainable from interest and
    dividends?", 
  location     = "http://www.aaii.com/journal/article/investing-for-income-in-a-low-interest-rate-environment"
}

@Article{kapoesfer,
  author       = "John Bajkowski",
  title        = "Keeping a Pulse on Expectations: Screening for Earnings Revisions",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 10,
  pages        = "10--12",
  month        = nov,
  keywords     = "screens, performance, portfolios",
  abstract     = "Slight changes in expectations for future earnings or the
    earnings growth rate can strongly impact a stock's price. Tracking these
    expectations and their changes can be a rewarding stock strategy.", 
  location     = "http://www.aaii.com/journal/article/keeping-a-pulse-on-expectations-screening-for-earnings-revisions"
}

@Article{sfdyfysmf,
  author       = "John Markese",
  title        = "Searching for Dividend Yield From Your Stock Mutual Funds",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 10,
  pages        = "15--17",
  month        = nov,
  keywords     = "yield, growth, reits, benchmarks, risk, expenses",
  abstract     = "Searching for more yield? One place to look is among stock
    funds with high dividend yields. Not only do dividend-paying stock funds
    have a growth component, qualified dividends receive advantageous tax rates
    under the new laws.",
  location     = "http://www.aaii.com/journal/article/searching-for-dividend-yield-from-your-stock-mutual-funds"
}

@Article{fotiisssp,
  author       = "James~B. Cloonan",
  title        = "Focus on the Individual Investor's Shadow Stock Portfolio",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 10,
  pages        = "23--26",
  month        = nov,
  keywords     = "portfolio, screens, microcaps",
  abstract     = "Presenting a model stock portfolio that can be the beginning
    of the selection process, but not all of it. There are many ways the
    strategy can be implemented without everyone buying the exact same
    stocks.", 
  location     = "http://www.aaii.com/journal/article/focus-on-the-individual-investor-s-shadow-stock-portfolio"
}

@Article{aisgtcita,
  author       = "John Deysher",
  title        = "An Investor's Guide to Corporate Insider Trading Activity",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 10,
  pages        = "27--29",
  month        = nov,
  keywords     = "sec forms, insider trading, analysis",
  abstract     = "Insider buying is much more significant than insider
    selling. Insiders may sell their shares for a variety of reasons. But
    typically insiders buy their shares on the open market for one reason--the
    stock is cheap!
",
  location     = "http://www.aaii.com/journal/article/an-investor-s-guide-to-corporate-insider-trading-activity"
}

@Article{nhietbf,
  author       = "Albert J. Fredman",
  title        = "New Horizons: Introducing Exchange-Traded Bond Funds",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 1,
  pages        = "5--10",
  month        = jan,
  keywords     = "bond etfs, decoupling, treasury fitrs, expenses, risks",
  abstract     = "Bond ETFs offer benefits similar to those of stock ETFs, such
    as low cost, diversification, the ability to trade shares throughout the
    day, and the ability to short a portfolio.",
  location     = "http://www.aaii.com/journal/article/new-horizons-introducing-exchange-traded-bond-funds"
}

@Article{mypwiib,
  author       = "Hildy Richelson",
  title        = "Maximizing Your Profits When Investing in Bonds",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 1,
  pages        = "24--29",
  month        = jan,
  keywords     = "timing, buy and hold, yield curve, overvaluations, rates,
    default risk",
  abstract     = "The experts can agree neither on which way interest rates
    will go next nor on what the shape of the yield curve means for interest
    rates in the future. However, you can still get significant information
    from studying the yield curve.", 
  location     = "http://www.aaii.com/journal/article/maximizing-your-profits-when-investing-in-bonds"
}

@Article{alatbpmomb,
  author       = "Wayne~A. Thorp",
  title        = "{A} Look at the Big Picture: Measures of Market Breadth",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 1,
  pages        = "30--34",
  month        = jan,
  keywords     = "issues traded, advancing/declining issues, advance/decline
    ratio, advance/decline line, absolute breadth index, volume, tick, traders
    index, block trades",
  abstract     = "The movement of many stocks is not effectively captured by
    most major market indexes, so many investors turn to market breadth
    indicators to gain a feel for the full range of stocks participating in the
    movement of the market.", 
  location     = "http://www.aaii.com/journal/article/a-look-at-the-big-picture-measures-of-market-breadth"
}

@Article{fbstgafstfp,
  author       = "Jay Taparia",
  title        = "Four Basic Steps to Gauging a Firm's True Financial Position",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 9,
  pages        = "8--11",
  month        = oct,
  keywords     = "cash flow, growth rates, financial analysis",
  abstract     = {A basic understanding of a company's "true" financial
    position can be gleaned by starting with a company's cash flow
    statement. Four initial steps you can use to analyze a firm's financial
    statements.},
  location     = "http://www.aaii.com/journal/article/four-basic-steps-to-gauging-a-firms-true-financial-position"
}

@Article{wyntkasbetf,
  author       = "AAII Staff",
  title        = "What You Need to Know About Stock-Based Exchange-Traded Funds",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 9,
  pages        = "12--24",
  month        = oct,
  keywords     = "indices, risks, trading, holders",
  abstract     = "",
  location     = "http://www.aaii.com/journal/article/what-you-need-to-know-about-fixed-income-exchange-traded-funds"
}

@Article{wyntkafietf,
  author       = "AAII Staff",
  title        = "What You Need to Know About Fixed-Income Exchange-Traded Funds",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 9,
  pages        = 25,
  month        = oct,
  keywords     = "bond etfs, tax efficiency",
  abstract     = "A look at the four newcomers to the exchange-traded fund
  universe--what bond indexes they track and how they work.",
  location     = "http://www.aaii.com/journal/article/what-you-need-to-know-about-fixed-income-exchange-traded-funds"
}

@Article{ajbfyalahyb,
  author       = "Annette Thau",
  title        = "Are Junk Bonds for You? {A} Look at High-Yield Bonds",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 9,
  pages        = "32--36",
  month        = oct,
  keywords     = "bond ratings, junk bond funds",
  abstract     = "One-year returns of junk bond funds averaged 20% in 2003
    after a two-year slump, tracking the stock market rebound. Is now a good
    time for indviduals to invest in this sector?",
  location     = "http://www.aaii.com/journal/article/are-junk-bonds-for-you-a-look-at-high-yield-bonds"
}

@Article{fblfmh,
  author       = "William Reichenstein",
  title        = "Ten Lessons You Should Learn From Recent Market History",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 2,
  pages        = "3--6",
  month        = feb,
  keywords     = "historical returns, risk moderation, disproportionate
    change, all bonds, conservative investing, rebalancing, market timint,
    asset classes, fixed weight", 
  abstract     = "The period from 1987 to 2002 encompassed the extremes,
    including two severe bear markets and one long bull market. How would
    various asset allocation strategies have fared during this time period? A
    valuable financial market history lesson.",
  location     = "http://www.aaii.com/journal/article/five-big-lessons-from-market-history"
}

@Article{tppopeapsr,
  author       = "Richard Goedde",
  title        = "The Predictive Power of Price-Earnings and Price-Sales Ratios",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 2,
  pages        = "7--9",
  month        = feb,
  keywords     = "deciles, predictions, stock selection",
  abstract     = "Both price-earnings and price-sales ratios are significant
    factors in predicting future stock price performance over the next year.",
  location     = "http://www.aaii.com/journal/article/the-predictive-power-of-price-earnings-and-price-sales-ratios"
}

@Article{itsiebcdafl,
  author       = "James~H. Gilkeson and Gary~E. Porter and Stanley~D. Smith",
  title        = "In Today's Investment Environment, Bank {CD}s Deserve a Fresh Look",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 2,
  pages        = "10--14",
  month        = feb,
  keywords     = "treasuries, cds, taxes, liquidity",
  abstract     = "With rising bond default rates and the lowest Treasury yields
    in more than a generation, investors would be wise to reconsider long-term
    bank time deposits as a way to earn safe returns in excess of money market
    yields.",
  location     = "http://www.aaii.com/journal/article/in-today-s-investment-environment-bank-cds-deserve-a-fresh-look"
}

@Article{ptapombi,
  author       = "Annette Thau",
  title        = "Putting Together a Portfolio of Municipal Bond Investments",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 2,
  pages        = "28--33",
  month        = feb,
  keywords     = "maturities, laddering, barbell, discounts, premiums, zeros,
    taxable munies",
  abstract     = "Any decision you make about fixed-income investments
    regarding maturities will involve trade-offs between the amount of income
    generated by your portfolio and the risk to the value of principal.",
  location     = "http://www.aaii.com/journal/article/putting-together-a-portfolio-of-municipal-bond-investments"
}

@Article{mcmfsftfg,
  author       = "John Markese",
  title        = "Micro-Cap Mutual Funds: Searching for the Future Giants",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 3,
  pages        = "3--5",
  month        = apr,
  keywords     = "market cap, performance, micro-caps",
  abstract     = "Micro-cap stocks are not as well covered as larger-cap
    stocks, and as a result a fund manager has a greater chance of adding
    significant value. They also do not track the overall market perfectly,
    adding to portfolio diversification.",
  location     = "http://www.aaii.com/journal/article/micro-cap-mutual-funds-searching-for-the-future-giants"
}

@Article{htsfbpmoti,
  author       = "Annette Thau",
  title        = "How to Shop for Bonds: Pricing Munis on the {I}nternet",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 3,
  pages        = "22--28",
  month        = apr,
  keywords     = "accrued interest, dated date, call provisions, bond pricing,
    bond markups, ",
  abstract     = "Buying municipal bonds is a little like buying a
    car--shopping around and doing some comparison. The frustrating aspect of
    munis is pricing and markups. The situation is improving, with pricing
    information slowly becoming available on the Internet.",
  location     = "http://www.aaii.com/journal/article/how-to-shop-for-bonds-pricing-munis-on-the-internet"
}

@Article{tabspaapr,
  author       = "James~B. Cloonan",
  title        = "The {AAII} {B}eginner's {P}ortfolio: An Annual Performance Review",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 3,
  pages        = "33--34",
  month        = apr,
  keywords     = "small cap, value stocks, portfolio management, performance",
  abstract     = "Over the last 10-year period, the Beginner's Portfolio has
    beaten the S&P 500, the Russell 2000, and the micro-cap index. This
    confirms what historical research has shown: Over the long run, small-cap
    stocks, on average, have higher returns.",
  location     = "http://www.aaii.com/journal/article/the-aaii-beginner-s-portfolio-an-annual-performance-review"
}

@Article{bmswtshts,
  author       = "T.~Rowe Price Associates",
  title        = "Bear Market Strategies: Watch the Spending, Hold the Stocks",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 4,
  pages        = "3--7",
  month        = may,
  keywords     = "portfolio, withdrawal rates, cash, equities, retirement",
  abstract     = "The asset allocation decision in retirement can be critical
    depending on your withdrawal rate and time horizon. Recent analysis shows
    that retirees should keep at least 30% to 40% in equities.",
  location     = "http://www.aaii.com/journal/article/bear-market-strategies-watch-the-spending-hold-the-stocks"
}

@Article{tcwbyratm,
  author       = "Wayne~A. Thorp",
  title        = "Telling Curves: What Bond Yields Reveal About the Markets",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 4,
  pages        = "14--17",
  month        = may,
  keywords     = "yield, yield curve, predictors",
  abstract     = "Studies have shown that the overall pattern of interest rate
    movements can provide an indication of the direction of future economic
    activity, as well as the markets themselves.",
  location     = "http://www.aaii.com/journal/article/telling-curves-what-bond-yields-reveal-about-the-markets"
}

@Article{t1faferi,
  author       = "William~P. Dukes",
  title        = "The 10 Fundamental Axioms for Effective Retirement Investing",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 4,
  pages        = "23--",
  month        = may,
  keywords     = "now, goals, historical expectations, risk management,
    diversify, long-term perspective, no timing, buy results, buy light,
    taxes",
  abstract     = "These principles provide the critical cornerstone for making
    decisions. When any of the axioms are violated, you risk being derailed
    from the ultimate objective of accumulating a more-than-adequate fund for
    retirement.", 
  location     = "http://www.aaii.com/journal/article/the-10-fundamental-axioms-for-effective-retirement-investing"
}

@Article{tpvrdygwypf,
  author       = "Mark Hulbert",
  title        = "The Price-Value Relationship: Do You Get What You Pay For?",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 4,
  pages        = "30--31",
  month        = may,
  keywords     = "cost, performance",
  abstract     = "Direct mail marketers say that in head-to-head tests of two
    investment newsletters that differ only in price, the higher-priced one
    often   receives more responses. Do more expensive newsletters provide
    better returns?", 
  location     = "http://www.aaii.com/journal/article/the-price-value-relationship-do-you-get-what-you-pay-for-"
}

@Article{tbphtdtsmsd,
  author       = "William~J. O'Neil",
  title        = "The Big Picture: How to Determine the Stock Market's Direction",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 5,
  pages        = "3--7",
  month        = jun,
  keywords     = "markets, cycles, bottoms, turns, tops",
  abstract     = "The CAN SLIM strategy has been a superior performer among the
    AAII stock screens. But our approach misses one aspect--market
    direction. William O'Neil himself describes how to gauge the market's
    direction.",
  location     = "http://www.aaii.com/journal/article/the-big-picture-how-to-determine-the-stock-market-s-direction"
}

@Article{tfofyahtgt,
  author       = "John Markese",
  title        = "Top Funds Over Five Years: Analyzing How They Got There",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 6,
  pages        = "3--6",
  month        = jul,
  keywords     = "fund evaluation, tax efficiency, category risk, total risk",
  abstract     = "Lists of top-performing funds can be dangerous to
    investors--the temptation to invest in the top funds without understanding
    how they got there is great.", 
  location     = "http://www.aaii.com/journal/article/top-funds-over-five-years-analyzing-how-they-got-there"
}

@Article{jhdiitttbm,
  author       = "Mark Hulbert",
  title        = "Just How Difficult Is It to Time the Bond Market?",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 6,
  pages        = "29--30",
  month        = jul,
  keywords     = "market timing, ",
  abstract     = "Bond market timers have faced tough challenges in recent
    years. Have they risen to the occasion?",
  location     = "http://www.aaii.com/journal/article/just-how-difficult-is-it-to-time-the-bond-market-"
}

@Article{saolwp,
  author       = "Savio Fernandes and Klm Reddy",
  title        = "Securing Applications on {L}inux with {PAM}",
  journal      = lj,
  year         = 2002,
  number       = 102,
  pages        = "70--81",
  month        = oct,
  keywords     = "security, user credentials",
  abstract     = "The basic concepts of PAM (Pluggable Authentication Module),
    developing a PAM-enabled application and writing the PAM configuration
    file.",
  location     = "http://www.linuxjournal.com/article/5940"
}

@Article{ttlpi,
  author       = "Greg Kroah-Hartman",
  title        = "The tty Layer, Part {II}",
  journal      = lj,
  year         = 2002,
  number       = 102,
  pages        = "50--58",
  month        = oct,
  keywords     = "ioctls, device drivers",
  abstract     = "In the first part of this column (LJ, August 2002) we covered
    the basics of the tty layer and how to create a minimal tty driver. Now we
    move on and cover more of the tty layer, trying to explain some of the
    advanced portions.", 
  location     = "http://www.linuxjournal.com/article/6226"
}

@Article{wdyhiyw,
  author       = "Alex Perry",
  title        = "What Do You Have in Your Walls?",
  journal      = lj,
  year         = 2002,
  number       = 102,
  pages        = "42--49",
  month        = oct,
  keywords     = "magnetic probes, signal processing, graph plotting",
  abstract     = "The physics, hardware and softwware behind an easy-to-build
    probe you can run with your sound card.",
  location     = "http://www.linuxjournal.com/article/6201"
}

@Article{psitjs,
  author       = "Roger Riggs and Jim Waldo and Ann Wollrath and Krishna Bharat",
  title        = "Pickling State in the {J}ava System",
  journal      = cs,
  year         = 1996,
  volume       = 9,
  number       = 4,
  pages        = "291--312",
  month        = "Fall",
  keywords     = "object model, object streams, object state",
  abstract     = "The Java system (hereafter referred to simply as Java)
    inherently supports the transmission of stateless computation in the form
    of object classes.In this paper we address the related task of capturing
    the state of a Java object in a serialized form for the purposes of
    transmission or storage, to be used later in reconstituting an equivalent
    object.  This is accomplished by a mechanism known as pickling [Binel et
    al. 1987; Binell et al. 1994; Herlihy & Liskov 19821.  Pickling is the
    process of creating a serialized representation of objects.  Pickling
    defines the serialized form to include meta information that identifies the
    type of each object and the relationships between objects within a stream.
    Values and types are serialized with enough information to insure that the
    equivalent typed object and the objects to which it refers can be
    recreated.  Unpickling is the complementary process of recreating objects
    from the serialized representation.  Pickling and unpickling extract from
    the Java Virtual machine, at runtime, any meta information needed to pickle
    the fields of objects.  Class specific methods are only required to
    customize the pickling process.", 
  location     = "http://www.usenix.org/publications/compsystems/1996/fall_riggs.pdf"
}

@Article{ssidal ,
  author       = "Mick Bauer",
  title        = "Stealthful Sniffing, Intrusion Detection and Logging",
  journal      = lj,
  year         = 2002,
  number       = 102,
  pages        = "34--40",
  month        = oct,
  keywords     = "stealth logging, snort, intrusion detection",
  location     = "http://www.linuxjournal.com/article/6222"
}

@Article{ldsm,
  author       = "Miroslaw Zakrezewski and Ibrahim Haddad",
  title        = "Linux Distributed Security Module",
  journal      = lj,
  year         = 2002,
  number       = 102,
  pages        = "20--28",
  month        = oct,
  keywords     = "mandatory access control, linux security module, distributed
    security, access control",
  abstract     = "Traditionally, the telecom industry has used clusters to 
    meet its carrier-grade requirements of high availability, reliability and
    scalability, while relying on cost-effective hardware and software.
    Efficient cluster security is now an essential requirement that has not yet
    been addressed in a coherent fashion.",
  location     = "http://www.linuxjournal.com/article/6215"
}

@Article{aetpladslacs,
  author       = "Don Batory and Clay Johnson and Bob MacDonald and Dale {von Heeder}",
  title        = "Achieving Extensibility Through Product-Lines and Domain-Specific Languages: {A} Case Study",
  journal      = tosem,
  year         = 2002,
  volume       = 11,
  number       = 2,
  pages        = "191--214",
  month        = apr,
  keywords     = "genvoca, domain-specific languages, simulation, aspects,
    refinements, software development, software design",
  abstract     = "This is a case study in the use of product-line architectures
    (PLAs) and domain-specific languages (DSLs) to design an extensible
    command-and-control simulator for Army fire support.  The reusable
    components of our PLA are layers or aspects whose addition or removal
    simultaneously impacts the source code of multiple objects in multiple,
    distributed programs.  The complexity of our component specifications is
    substantially reduced by using a DSL for defining and refining state
    machines, abstractions that are fundamental to simulators.  We present
    preliminary results that show how our PLA and DSL synergistically produce a
    more flexible way of implementing state-machine-based simulators than is
    possible with a pure Java implementation.", 
  location     = "http://dx.doi.org/10.1145/505145.505147"
}

@Article{satecwpwaw,
  author       = "Wayne~A. Thorp",
  title        = "Stocks and the Economic Cycle: What Performs Well---and When",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 7,
  pages        = "8--13",
  month        = aug,
  keywords     = "business cycle, recessions, expansions, sector rotation",
  abstract     = "While stocks as a whole move in advance of the economy,
    specific sectors have different relative performance throughout the
    economic cycle.",
  location     = "http://www.aaii.com/journal/article/stocks-and-the-economic-cycle-what-performs-well-and-when"
}

@Article{tt1eiwtwaw,
  author       = "AAII Staff",
  title        = "The Top 10 Economic Indicators: What to Watch and Why",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 7,
  pages        = "14--17",
  month        = aug,
  keywords     = "gdb, money supply, cpi, ppi, ces, housing starts,
    inventories, stock indices",
  abstract     = "",
  location     = "http://www.aaii.com/journal/article/the-top-10-economic-indicators-what-to-watch-and-why"
}

@Article{aslptssspimm,
  author       = "John Bajkowski",
  title        = "{AAII}'s Low Price-to-Sales Screen: Strong Performer in Mixed Market",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 8,
  pages        = "3--5",
  month        = sep,
  keywords     = "stock analysis, screens",
  abstract     = "Screening provides a disciplined aproach to selecting stocks
    that match up with one's investment philosophy. However, it's a first step
    in the stock selection process and should be followed up with in-dpeth
    company analysis.",
  location     = "http://www.aaii.com/journal/article/aaii-s-low-price-to-sales-screen-strong-performer-in-mixed-market"
}

@Article{awiabmboabmc,
  author       = "Mark Hulbert",
  title        = "Are We in a Bull Market Beginning or a Bear Market Correction?",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 8,
  pages        = "6--7",
  month        = sep,
  keywords     = "market status, ",
  abstract     = "Since March 2003, small-cap growth stocks have outperformed
    small-cap value stocks. This is more reminiscent of the speculative
    behavior prior to major market tops than the beginning of a new bull
    market.", 
  location     = "http://www.aaii.com/journal/article/are-we-in-a-bull-market-beginning-or-a-bear-market-correction-"
}

@Article{nfasgosafs,
  author       = "James~B. Cloonan",
  title        = "New From {AAII}: Specific Guidance on Stock and Fund Selection",
  journal      = aaiij,
  year         = 2003,
  volume       = 25,
  number       = 8,
  pages        = "54--56",
  month        = sep,
  keywords     = "shadow stocks, portfolios, stock selection",
  abstract     = "AAII Chairman Jim Cloonan expands coverage of the model stock
    portfolio and constructs a model mutual fund portfolio. Both share the same
    philosophy:  consistency, risk control and selections that are best for
    individuals rather than institutions.",
  location     = "http://www.aaii.com/journal/article/new-from-aaii-specific-guidance-on-stock-and-fund-selection"
}

@Article{pfws,
  author       = "Jeremy Garcia",
  title        = "Port Forwarding with {SSH}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = 12,
  month        = nov,
  keywords     = "ssh, port forwarding, security",
  abstract     = "If you've administered any remote Linux machines then you are
    already familiar with SSH, but you might not know that you can use SSH for
    much more than just connecting to a shell on a remote system.  By using
    SSH's port forwarding features, you can set up encrypted tunnels for many
    services, or connect to systems behind a firewall from home.", 
  location     = "http://www.linux-mag.com/id/5104/"
}

@Article{bcfwpt,
  author       = "Jerry Peek",
  title        = "Boot Camp For Wizards, Part Three",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "16--18",
  month        = nov,
  keywords     = "file descriptors, file redirection, filenames, named pipes",
  abstract     = "This month, more about using open files from a shell:
    manipulating file descriptors, using named pipes (FIFOs), as well as why
    you would (and wouldn't) want a file without a name.",
  location     = "http://www.linux-mag.com/id/5103"
}

@Article{gitk,
  author       = "Arjan {van de Ven}",
  title        = "Graphics Into the Kernel?",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "20, 52",
  month        = nov,
  keywords     = "x, graphics drivers, os design",
  abstract     = "Whether or not the graphics subsystem is part of the 
    operating system's kernel or not is highly controversial, and popular
    opinion seems to change over time.  For example, a certain other major OS
    has had graphics in, and then out of, the kernel several times now.", 
  location     = "http://www.linux-mag.com/id/4825/"
}

@Article{itdah,
  author       = "Alan Holt",
  title        = "Introduction to {DCCP}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "34--37, 53",
  month        = nov,
  keywords     = "tcp, udp, congestion control, dccp "
}

@Article{itpd,
  author       = "Matthew Wilson",
  title        = "Introduction to {P}ython Decorators",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "46--52",
  month        = nov,
  keywords     = "python, metaprogramming, decorators, wrappers",
  abstract     = "Have a web app that occasionally hangs? Use signals to add a
    timeout to function requests with Python decorators.",
  location     = "http://www.linux-mag.com/id/5377/"
}

@Article{v1br,
  author       = "Benjamin Rudolph",
  title        = "Virtualization 101",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "10--11",
  month        = dec,
  keywords     = "paravirtualization, emulation, hardware",
  abstract     = "Being technical, you're probably eager to jump into the how
    of virt.  But let's take a step back for a minute and look at just what
    this technology is.",
  location     = "http://www.linux-mag.com/id/5508/"
}

@Article{bcfwpf,
  author       = "Jerry Peek",
  title        = "Boot Camp for Wizards, Part Four",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "18--19, 52",
  month        = dec,
  keywords     = "process management, ps, terminals, ",
  location     = "http://www.jpeek.com/articles/linuxmag/0712.pdf"
}

@Article{eolw,
  author       = "Arjan {van de Ven}",
  title        = "Evolution of {L}inux Wireless",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "20--21",
  month        = nov,
  keywords     = "hardmac, softmac, wireless"
}

@Article{eswpk,
  author       = "Khurram Shiraz",
  title        = "Enhance Security with Port Knocking",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "30--32",
  month        = dec,
  keywords     = "security, port knocking, firewalls, ",
  abstract     = "The author of All I Really Need to Know I Learned in 
    Kindergarten left out (at least) one important lesson: Secret knocks are
    really, really useful.  As kids, we'd use secret knocks to keep
    undesirables (the kids we didn't like) out of our clubs or rooms.  As
    system administrators, we can use secret knocks to protect our systems from
    crackers.",
  location     = "http://www.linux-mag.com/id/5445/"
}

@Article{oflrws,
  author       = "Roderick W. Smith",
  title        = "{OCR} for {L}inux",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "38--40",
  month        = dec,
  keywords     = "ocr software, ocr scanners",
  abstract     = "Rod Smith covers the optical character recognition (OCR)
    options for Linux, their limitations, and how to install and use Tesseract
    for your OCR needs on Linux.",
  location     = "http://www.linux-mag.com/id/5320/"
}

@Article{stfynkyh,
  author       = "Jeffrey~B. Layton",
  title        = "strace --- The Friend You Never Knew You Had",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "42--43, 52",
  month        = dec,
  keywords     = "output analysis, timing analysis",
  abstract     = "While strace is often used for troubleshooting and debugging,
    you can also use strace to get started on examining the I/O pattern of your
    serial codes.",
  location     = "http://www.linux-mag.com/id/5509/"
}

@Article{ttpoow20dwgwt,
  author       = "Sumit Chandel",
  title        = "Taking the Pain Out of {W}eb 2.0 Development with {G}oogle {W}eb {T}oolkit",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 11,
  pages        = "44--51",
  month        = dec,
  keywords     = "gwt, web development, ajax, java, cross compilation, ui
    layout" 
}

@Article{wbcps,
  author       = "Jerry Peek",
  title        = "Wizard  Boot Camp, Part Seven",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 3,
  pages        = "18--21",
  month        = mar,
  keywords     = "/proc, psuedo file systems",
  abstract     = "Digging into the dark corners of /proc pseudo-filesystem to 
    wrap up our discussion of Linux processes.",
  location     = "http://www.linux-mag.com/id/6458/"
}

@Article{cisoodd,
  author       = "Alan Holt",
  title        = "Controlling Input\slash Output of Device Drivers",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 3,
  pages        = "22--25",
  month        = mar,
  keywords     = "ioctl, system calls, network interfaces, wireless
    interfaces", 
  abstract     = "Hands-on tutorial for monitoring and configuring I/O for
    network device drivers at the Kernel level.",
  location     = "http://www.linux-mag.com/id/6206/"
}

@Article{tccpt,
  author       = "Roderick~W. Smith",
  title        = "Thin Client Computing, Part Two",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 3,
  pages        = "44--45, 53",
  month        = mar,
  keywords     = "thin clients, tftp",
  abstract     = "Now that our servers are in place, we walk through
    configuring an x86 PC as a thin client workstation.",
  location     = "http://www.linux-mag.com/id/6255/"
}

@Article{pcphm,
  author       = "Per Harald Myrvang",
  title        = "Parameterized Communication",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "22--26",
  month        = oct,
  keywords     = "secruity, reflection, introspection",
  abstract     = "Obol is a Lisp-like, domain-specific language for testing and
    experimenting with when constructing and using security protocols in real
    systems.", 
  location     = "http://www.drdobbs.com/security/192503712"
}

@Article{jcacm,
  author       = "Snezana Sucurovic and Zoran Jovanovic",
  title        = "Java Cryptography \& Attribute Certificate Management",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "28--34",
  month        = oct,
  keywords     = "cryptography, x.509, ",
  abstract     = "Since Java doesn't support attribute certificate generation
    and management, our authors built a provider called IMPCS that does.",
  location     = "http://www.drdobbs.com/jvm/java-cryptography-attribute-certificate/192600528"
}

@Article{tsaf,
  author       = "Arnon Rotem-Gal-Oz",
  title        = "The {SPAMMED} Architecture Framework",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "39--44",
  month        = oct,
  keywords     = "quality attributes, technology maps, evaluation",
  abstract     = "The SPAMMED Architecture Framework Arnon presents here helps
    you identify the steps and activities you need to design, model, and build
    successful architectures.",
  location     = "http://www.drdobbs.com/architecture-and-design/the-spammed-architecture-framework/192600570"
}

@Article{arldph,
  author       = "David Perelman-Hall",
  title        = "{AJAX} \& Record Locking",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "45--51",
  month        = oct,
  keywords     = "server-side components, client-side components",
  abstract     = "David Perelman-Hall presents a client-based technique for
    record locking of multiuser data-driven web applications--and it all hinges
    on AJAX.", 
  location     = "http://www.drdobbs.com/web-development/ajax-record-locking/192700218"
}

@Article{bedf,
  author       = "Mark Ramsay",
  title        = "Building Extensible Development Frameworks",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "53--57",
  month        = oct,
  keywords     = "user-interface service, ",
  abstract     = "When development teams work independently, third-party
    components like CodeJock's User Interface controls provide one way of
    encouraging code reuse.",
  location     = "http://www.drdobbs.com/article/print?articleId=192700231&dept_url=/cpp/"
}

@Article{arjd,
  author       = "Joe Duffy",
  title        = "Application Responsiveness",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "59--62",
  month        = oct,
  keywords     = "gui events, platform mitigations",
  abstract     = "A responsive UI is a happy UI. It’s snappy, responds to input
    promptly, and doesn't leave users hanging. But that's easier said than
    done.",
  location     = "http://www.drdobbs.com/windows/application-responsiveness/192700235"
}

@Article{itva,
  author       = "Mark Mitchell",
  title        = "Inside the {VSIPL}++ {API}",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "63--69",
  month        = oct,
  keywords     = "computation, performance, parallel computation",
  abstract     = "VSIPL++ is a C++ API for high-performance computing. One
    unique feature of it is that it includes direct support for parallel
    applications.",
  location     = "http://www.drdobbs.com/cpp/inside-the-vsipl-api/192501827"
}

@Article{iospb,
  author       = "Pete Becker",
  title        = "Illusions of Safety",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 10,
  pages        = "71--75",
  month        = oct,
  keywords     = "buffer overruns",
  abstract     = "Buffer overruns—just maybe C's biggest bugaboo. Luckily, TR
    24731 addresses the problem so that you can write fast, robust, and correct
    applications.",
  location     = "http://www.drdobbs.com/cpp/illusions-of-safety/192700250"
}

@Article{wbcpsix,
  author       = "Jerry Peek",
  title        = "Wizard Boot Camp, Part Six",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 2,
  pages        = "12--13, 52--53",
  month        = feb,
  keywords     = "daemons, shell scripts, subshell suspension",
  abstract     = "More about processes and signals: writing daemons, suspending
    subshells.", 
  location     = "http://www.linux-mag.com/id/5981/"
}

@Article{mtikusab,
  author       = "Anas Sharif",
  title        = "Manageability Technologies In Kernel, User Space, and Beyond",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 2,
  pages        = "14--15, 53",
  month        = feb,
  keywords     = "out-of-band management, in-band access, common data model",
  abstract     = "Managing a Linux system can be as easy as connecting to a 
    remote system and run some of the system tool available with most Linux
    distributions.  It gets difficult when you have to manage multiple remote
    systems, and many Linux admins do work in environments with hundreds or
    even thousands of systems.",
  location     = "http://www.linux-mag.com/id/4671"
}

@Article{tccpo,
  author       = "Roderick~W. Smith",
  title        = "Thin Client Computing, Part One",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 2,
  pages        = "34--37",
  month        = feb,
  keywords     = "dhcp, servers, tftp, x, xdmcp, vnc",
  abstract     = "Thin clients offer an approach to computing with a number of 
    advantages over the more common desktop computer approach.  Learn how to
    enable it.",
  location     = "http://www.linux-mag.com/id/6207/"
}

@Article{usffap,
  author       = "Jeffrey~B. Layton",
  title        = "Using {strace} for Fun and Profit",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 2,
  pages        = "38--39, 55",
  month        = feb,
  keywords     = "strace, system calls",
  abstract     = "New tool for taking the output from strace_analyzer and
    creating a simulation of the I/O pattern of your code on different storage
    hardware and file systems.",
  location     = "http://www.linux-mag.com/id/6711/"
}

@Article{ttpoow20dwgwti,
  author       = "Sumit Chandel",
  title        = "Taking the Pain Out of {Web} 2.0 Development with {Google Web Toolkit {II}}",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 2,
  pages        = "40--50",
  month        = feb,
  keywords     = "gwt, client-server, web development, rpc, struts, spring
   mvc" 
}

@Article{talaoacfs,
  author       = "Jeremy Garcia",
  title        = "Taking a Look at {OCFS2}, a Clustering File System",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 4,
  pages        = "16--17",
  month        = apr,
  keywords     = "file system"
}

@Article{wbcpe,
  author       = "Jerry Peek",
  title        = "Wizard Boot Camp, Part Eight",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 4,
  pages        = "22--24",
  month        = apr,
  keywords     = "cat, echo, date, touch, grep, gzip, bzip2",
  abstract     = "Before you reach for that scripting language, make sure
    you're making the most of the shell utilities that you have at your
    fingertips!",
  location     = "http://www.linux-mag.com/id/6657/"
}

@Article{uzcs,
  author       = "Cindy Swearingen",
  title        = "Using {ZFS}",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 4,
  pages        = "34--36",
  month        = apr,
  keywords     = "storage pools, mirroring, hot spares"
}

@Article{rtesb,
  author       = "Paul Fremantle",
  title        = "Ride the Enterprise Service Bus",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 8,
  pages        = "38--40",
  month        = apr,
  keywords     = "request logging, "
}

@Article{mtpc,
  author       = "Jeffrey~B. Layton",
  title        = "Meeting the Petabyte Challange",
  journal      = lmag,
  year         = 2008,
  volume       = 10,
  number       = 4,
  pages        = "42--47, 52--53",
  month        = apr,
  keywords     = "storage technology, massive storage"
}

@Article{rtdd,
  author       = "Linda Briggs and Kari Boyd McBride",
  title        = "Rethinking the Digital Divide",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "108,106--107",
  month        = oct,
  keywords     = "teaching, netizens, brazil",
  abstract     = "In our search for transgressive models of distance 
    education, we found inspiration in the Web-back performance pieces of
    Guillermo Gomez-Penia (1997), the production of virtual favelas in Brazil,
    and rural education models from the Philippines and Malaysia.  As we
    thought in particular about our desire to reach Native American
    reservations and Mexican-American border towns in the US Southwest, we
    asked how these various Third World projects profile and recruit their
    students and what models of virtual education and empowerment they
    create.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039527"
}

@Article{ttpsds ,
  author       = "Andrew ``bunnie'' Huang",
  title        = "The Trusted {PC}: Skin-Deep Security",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "103--105",
  month        = oct,
  keywords     = "sealed storage, security, spam, spios, interoperability,
    guarded tags, data tags",
  abstract     = "Current efforts to secure the PCs traditionally open
    architecture will give consumers two unattractive choices: They will either
    have to pay a huge premium for an unwieldy system that employs impenetrable
    membranes, encrypted buses, and tamper-resistant memory, or they will have
    to settle for an inferior solution that fails to thwart dishonest users and
    limits the ability to backup data and interoperate with third-party
    software.  Investing in proven architectural improvements such as guarded
    pointers and data tags is a more cost-effective and long-overdue
    alternative.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039525"
}

@Article{ttmi ,
  author       = "Josef~F. Huber",
  title        = "Toward the Mobile Internet",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "100--102",
  month        = oct,
  keywords     = "infrastructure evolution, future services",
  abstract     = "The promise of ubiquitous computing is a future in which
    highly specialized, embedded computing devices operate seamlessly within
    the everyday environment and are transparent to users.  Realizing this
    vision will require next-generation networks to support mobile multimedia
    devices with capabilities well beyond those of today's handsets.  These
    networks will exploit wideband radio access technologies and IP-based
    protocols to provide IP transparency-all network elements support IP;
    mobility management for a globally networked environment; unique addressing
    for every user; personalization of information; positioning to enable
    location-dependent services; and end-to-end security.  Such functionality
    requires more than providing wireless Internet access and e-mail.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039524"
}

@Article{tcgwhu ,
  author       = "Michael Macedonia",
  title        = "The Computer Graphics Wars Heat Up",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "97--99",
  month        = oct,
  keywords     = "console games, graphics cards, nvidia",
  abstract     = "The author describes the present status of computer graphics
    hardware.  While console games flourished, PC game sales have plummeted.
    The plans of Nvidia and ATI, the 3D graphics world's two dominant players
    are described.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039523"
}

@Article{dsddtcot ,
  author       = "Samitha Samaranayake and Nodari Sitchinava and Rohit Kapur
    and Minesh~B. Amin and Thomas~W. Williams",
  title        = "Dynamic Scan: Driving Down the Cost of Test",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "63--68",
  month        = oct,
  keywords     = "current scan tests, scan segments",
  abstract     = "Two factors primarily drive the soaring cost of semiconductor
    test: the number of test patterns applied to each chip and the time it
    takes to run each pattern.  Typical semiconductor testing for each chip
    involves a set of1,000 to 5,000 test patterns.  These tests are applied
    through scan chains that operate at about 25 MHz.  Depending in the size of
    the scan chains on the chip, a set of test patterns can take a few seconds
    to execute per chip.  It's easy to see that even a small decrease in either
    the number of patterns or the time to execute them can quickly add up to
    big savings across millions of fabricated chips.  This potential savings
    forms the basis for dynamic scan, a new approach to the well-established
    scan test methodology.  The authors' initial studies indicate that dynamic
    scan could easily reduce the time spent applying test patterns by 40
    percent.  A more theoretical analysis shows a potential savings of as much
    as 80 percent.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039519"
}

@Article{dosisn ,
  author       = "Anthony~D. Wood and John~A. Stankovic",
  title        = "Denial of Service in Sensor Networks",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "54--62",
  month        = oct,
  keywords     = "dos, jamming, tampering, collision, exhaustion, unfairness,
    homing, misdirection, black holes, authorization, monitoring, probing,
    redundancy, flooding, desynchronization, adaptive rate control, ",
  abstract     = "Sensor networks hold the promise of facilitating large-scale,
    real-time data processing in complex environments, environments, helping to
    protect and monitor military, environmental, safety-critical, or domestic
    infrastructures and resources.  Denial-of-service attacks against such
    networks, however, may permit real world damage to public health and
    safety.  Without proper security mechanisms, networks will be confined to
    limited, controlled environments, negating much of the promise they hold.
    The limited ability of individual sensor nodes to thwart failure or attack
    makes ensuring network availability more difficult.  To identify
    denial-of-service vulnerabilities, the authors analyzed two effective
    sensor network protocols that did not initially consider security.  These
    examples demonstrate that consideration of security at design time is the
    best way to ensure successful network deployment.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039518"
}

@Article{rslac ,
  author       = "Suman Banerjee and Sulabh Agarwal and Kevin Kamel and Andrzej
    Kochut and Christopher Kommareddy and Tamer Nadeem and Pankaj Thakkar and
    Bao Trinh and Adel Youssef and Moustafa Youssef and Ronald~L. Larsen and
    A.~Udaya Shankar and Ashok Agrawala", 
  title        = "Rover: Scalable Location-Aware Computing",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "46--53",
  month        = oct,
  keywords     = "scalability, action model, communication interfaces, initial
    implementation", 
  abstract     = "All the components necessary for realizing location-aware
    computing are available in the marketplace today.  What has hindered the
    widespread deployment of location-based systems is the lack of an
    integration architecture that scales with user populations.  The authors
    have completed the initial implementation of Rover, a system designed to
    achieve this sort of integration and to automatically tailor information
    and services to a mobile user's location.  Their studies have validated
    Rover's underlying software architecture, which achieves system scalability
    through high resolution,application-specific resource scheduling at the
    servers and network.  The authors believe that this technology will greatly
    enhance the user experience in many places, including museums, amusement
    and theme parks, shopping malls,game fields, offices, and business centers.
    They designed the system specifically to scale to large user populations
    and expect its benefits to increase with them.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039517"
}

@Article{wiuvsid ,
  author       = "Bill~N. Schilit and Jonathan Trevor and David~M. Hilbert and
    Tzu Khiau Koh", 
  title        = "Web Interaction Using Very Small Internet Devices",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "37--45",
  month        = oct,
  keywords     = "m-links, mobile services",
  abstract     = "Internet-enabled cell phones typically accommodate only three
    to 12 text lines, and their design emphasizes portability.  Web interaction
    has, so far, been a secondary concern.  For the most part, automated
    techniques to address the feature gap between the desktop and these phone
    tops rely on the notion of transducing--translating HTML and images into
    formats compatible with small devices, which typically cannot handle HTML
    content.  The authors have developed a Web browsing model that supports
    navigation and action in separate interfaces.  To demonstrate the model,
    they created m-Links, a middleware proxy system that retrieves Web
    documents using HTTP,lets users navigate and apply services to Web content,
    and delivers a suitable user interface to a variety of small Web-capable
    wireless devices.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039516"
}

@Article{teodr ,
  author       = "Ravi Kalakota and Pavan Gundepudi and Jonathan Wareham and
    Arun Rai and Richard Welke",
  title        = "The Economics of {DSL} Regulation",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 10,
  pages        = "29--36",
  month        = oct,
  keywords     = "telecommunications act of 1996, dsl market, last mile, market
    behavior",
  abstract     = "Despite a growing demand for high-speed Internet and network
    access in the US broadband market, many digital-subscriber-line companies
    are downsizing, scaling back service, or closing their doors altogether.
    More importantly,upstart independent DSL provider shave gone to war with
    the Baby Bells,alleging that they have purposely accelerated the shakeout
    of start-up companies by exploiting all DSL providers' dependence on the
    last-mile network infrastructure that the Baby Bells provide.  Separating
    the economic interests of incumbent exchange carriers and their affiliates
    will ultimately serve consumers best.  An open market for DSL access run
    exclusively by the Baby Bells would avoid existing distortions and let
    regulation focus on encouraging the regional Bell operating companies to
    provide access to underrepresented areas where investment would otherwise
    be unjustified.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1039515"
}

@Article{acotpfdsm,
  author       = "Willem~G. Levelt and M.~Frans Kaashoek and Henri~E. Bal and
    Andrew~S. Tannenbaum",
  title        = "{A} Comparison of two Paradigms for Distributed Shared Memory",
  journal      = spe,
  year         = 1992,
  volume       = 22,
  number       = 11,
  pages        = "985--1010",
  month        = nov,
  keywords     = "amoeba, distributed shared memory, distributed programming,
    orca, shared-data objects, shared virtual memory",
  abstract     = "This paper compares two paradigms for Distributed Shared
    Memory on loosely coupled computing systems: the shared data-object model
    as used in Orca, a programming language specially designed for loosely
    coupled computing systems and the Shared Virtual Memory model.  For both
    paradigms two systems are described, one using only point-to-point
    messages, the other using broadcasting as well.  The two paradigms and
    their implementations are described briefly.  Their performances on four
    applications are compared: the traveling-salesman problem, alpha-beta
    search, matrix multiplication and the all-pairs shortest paths problem.
    The relevant measurements were obtained on a system consisting of 10
    MC68020 processors connected by an Ethernet.  For comparison purposes, the
    applications have also been run on a system with physical shared memory.
    In addition, the paper gives measurements for the first two applications
    above when Remote Procedure Call is used as the communication mechanism.
    The measurements show that both paradigms can be used efficiently for
    programming large-grain parallel applications, with significant speed-ups.
    The structured shared data-object model achieves the highest speed-ups and
    is easiest to program and to debug.", 
  location     = "http://dx.doi.org/10.1002/spe.4380221105"
}

@Article{otfgcaeic,
  author       = "Edsger~W. Dijkstra and Leslie Lamport and A.~J. Martin and
    C.~S. Scholten and E.~F.~M. Steffens",
  title        = "On-the-Fly Garbage Collection: An Exercise in Cooperation",
  journal      = cacm,
  year         = 1978,
  volume       = 21,
  number       = 11,
  pages        = "966--975",
  month        = nov,
  keywords     = "concurrent garbage collection, white-grey-black,
    multiprocessing, fine-grained interleaving, cooperation, sequential
    processes, mutual exclusion, program correctness",
  abstract     = "As an example of cooperation between sequential processes
    with very little mutual interference despite frequent manipulations of a
    large shared data space, a technique is developed which allows nearly all
    of the activity needed for garbage detection and collection to be performed
    by an additional processor operating concurrently with the processor
    devoted to the computation proper.  Exclusion and synchronization
    constraints have been kept as weak as could be achieved; the severe
    complexities engendered by doing so are illustrated.", 
  location     = "http://dx.doi.org/10.1145/359642.359655"
}

@Article{fpravdv,
  author       = "Arjan {van de Ven}",
  title        = "Fighting Performance Regression",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 10,
  pages        = "16--17",
  month        = oct,
  keywords     = "benchmarks, performance testing, kernel performance",
  abstract     = "Arjan Van De Ven shines some light on the issues, projects,
    and techniques that characterize kernel performance.",
  location     = "http://www.linux-mag.com/id/4674/"
}

@Article{svkh,
  author       = "Ken Hess",
  title        = "{\tt sudo} Voodoo",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 10,
  pages        = "18--19, 52",
  month        = oct,
  keywords     = "sudo, system management, security",
  abstract     = "Using the root account for day-to-day work is a bad idea.
    It's better to use sudo to act like root when you need to do a little
    system administration.",
  location     = "http://www.linux-mag.com/id/4824/"
}

@Article{prpclm,
  author       = "Chromatic",
  title        = "Programming Reusable {PIR}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 10,
  pages        = "20--28, 55",
  month        = oct,
  keywords     = "subroutines, multi-dispatch, namespaces, code management",
  abstract     = "PIR is Parrot's native programming language.  In this
    conclusion of his series, chromatic presents a variety of techniques to
    program and validate subroutines.  Learn how to create libraries and test
    your code in this hands-on primer.", 
  location     = "http://www.linux-mag.com/id/4561/"
}

@Article{lloo,
  author       = "Martin Streicher",
  title        = "Lua, {Lua}, Oh, Oh",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 10,
  pages        = "36--40, 52",
  month        = oct,
  keywords     = "scripting, embedded languages, metatables",
  abstract     = "Compiled programming languages and scripting languages each
    have unique advantages, but what if you could use both to create rich
    applications? Lua is an embeddable scripting language that is small, fast,
    and very powerful.  Before you create yet another configuration file or
    resource format (and yet another parser to accompany it), try Lua.", 
  location     = "http://www.linux-mag.com/id/4678/"
}

@Article{njbllm,
  author       = "Jeffrey B. Layton",
  title        = "{NILFS}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 10,
  pages        = "42--45",
  month        = oct,
  keywords     = "file systems, journaling file systems, checkpointing,
    snapshots, garbage collection, ",
  abstract     = "The 2.6.30 kernel is chock full of next-gen file systems.
    One such example is NILFS, a new log-structured file system that
    dramatically improves write performance.", 
  location     = "http://www.linux-mag.com/id/7345/"
}

@Article{wsgp7,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part Seven",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 4,
  pages        = "12--17",
  month        = apr,
  keywords     = "unix commands, wc, diff, du, date, sed, touch",
  abstract     = "Here’s the last in a series about new features of perennial
    utilities.  This time: date, wc, du, and more.", 
  location     = "http://www.jpeek.com/articles/linuxmag/2006-04/"
}

@Article{msf,
  author       = "Sreekrishnan Venkateswaran",
  title        = "Manipulating ``Seq'' files",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 4,
  pages        = "26--32",
  month        = apr,
  keywords     = "procfs, seq files, nvram drivers, ",
  abstract     = "The process file system is a window into the mystical
    innards of the kernel.  The seq file interface simplifies the job of
    process file creators.",
  location     = "http://www.linux-mag.com/id/2739/"
}

@Article{gv3sfsgnw,
  author       = "Pamela Jones",
  title        = "{GPL} Version 3: So Far, So Good.  Now What?",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 4,
  pages        = "34--38",
  month        = apr,
  keywords     = "licenses, termination, patent clauses, drafting, gpl v2",
  abstract     = "For more than ten years, the GNU General Public License has
    provided the legal foundation for much of what’s been accomplished with
    free and open source software.  Now the license’s steward, the Free
    Software Foundation, is revising the venerable document to comprehend the
    complexities of developing and distributing open source software in the
    modern day.  In this exclusive article, Groklaw founder and editor Pamela
    Jones analyzes many of the proposed changes found in GPL Version 3 and
    explains what’s in store for you if your name is Joe Coder.", 
  location     = "http://www.linux-mag.com/id/2498/"
}

@Article{cynwo,
  author       = "Paul Duncan",
  title        = "Cast Your Net with {OpenVPN}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 4,
  pages        = "40--49",
  month        = apr,
  keywords     = "authentication, public keys, certification, pki, security,
    man in the middle, routing",
  abstract     = "A virtual private network (VPN) extends the resources of your
    local area network to telecommuter’s home, satellite offices, and far-flung
    sales warriors.  OpenVPN is a fast, scalable, secure, and free VPN solution
    for Linux.  And best of all, it’s easy to configure and deploy.  Here’s a
    hands-on primer.",
  location     = "http://www.linux-mag.com/id/2502/"
}

@Article{lmnw,
  author       = "Conor Svensson",
  title        = "Look, {Ma}, No Wires!",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 4,
  pages        = "50--53",
  month        = apr,
  keywords     = "ndiswrapper, wireless networking"
}

@Article{motcl,
  author       = "Scott Granneman",
  title        = "Music on the Command Line",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 9,
  pages        = 10,
  month        = sep,
  keywords     = "mp3 players, audio",
  abstract     = "Remotely control your tunes with MPD and ncmpc.",
  location     = "http://www.linux-mag.com/id/3855/"
}

@Article{wbcpo,
  author       = "Jerry Peek",
  title        = "Wizard Boot Camp: Part One",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 9,
  pages        = "16--19",
  month        = sep,
  keywords     = "shell, command interpretation, shell expansion, quoting",
  abstract     = "Here's the start of a series on little-known topics that
    wizards should know.  Knowledge of the Harry Potter series not required.",
  location     = "http://www.linux-mag.com/id/4038/"
}

@Article{srakh,
  author       = "Kenneth Hess",
  title        = "Secure Remote Access",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 9,
  pages        = "24--26",
  month        = sep,
  keywords     = "ssh, x11 forwarding, vnc tunneling, remote connections",
  abstract     = "Connecting to your home computer from work, a friend's house,
    or while on vacation in another country is very simple — if you know how to
    use a small handful of tools.  Ken Hess shows you how to connect securely
    and tunnel traffic using SSH.",
  location     = "http://www.linux-mag.com/id/4523/"
}

@Article{ppclmag,
  author       = "chromatic",
  title        = "Programming {PIR}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 9,
  pages        = "32--37, 55",
  month        = sep,
  keywords     = "opcodes, registers, syntax, parrot, compilation units, mpcs,
    subroutines",
  abstract     = "Parrot is not just a virtual machine for running dynamic
    languages; it also includes several tools for building dynamic languages,
    including a grammars engine and a tree transformation system.  Currently,
    all of these tools are available through PIR, Parrot's native programming
    language.", 
  location     = "http://www.linux-mag.com/id/4562/"
}

@Article{pfeadc,
  author       = "Eric Allen and David Chase and Christine Flood and Victor
    Luchangco and Jan-Willem Maessen and Sukyoung Ryu and Guy~L. {Steele Jr.}",
  title        = "Project {F}ortress",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 9,
  pages        = "38--43",
  month        = sep,
  keywords     = "high-performance computing, fortran, language design,
    mathematical notation, type systems, ",
  abstract     = "The world of multicore processing is coming soon, requiring
    new languages and programming techniques to leverage it smoothly.  Fortress
    could be our best hope for doing just that.",
  location     = "http://www.linux-mag.com/id/4730/"
}

@Article{cdbsg,
  author       = "Scott Granneman",
  title        = "Comprehensive Desktop Backup",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 8,
  pages        = "14",
  month        = aug,
  keywords     = "hard drives, mount points",
  abstract     = "A few hard drives and rsync make a simple and effective
    onsite backup system.  Scott Granneman shows you how to keep your desktop
    data safe.",
  location     = "http://www.linux-mag.com/id/4489/"
}

@Article{atopc,
  author       = "chromatic",
  title        = "{A} Tour of {P}arrot",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 8,
  pages        = "26--30, 52",
  month        = aug,
  keywords     = "registers, magic cookies, compiler tools",
  abstract     = "Besides serving as what is hoped to be an appropriate and 
    effective platform for Perl 6 and other languages, Parrot is a grand
    experiment.  Is there a better way to write a compiler than using the lex
    and yacc model? Can languages interoperate at a deeper level than sharing a
    set of calling conventions? Here are some answers.", 
  location     = "http://www.linux-mag.com/id/4197/"
}

@Article{fptpjbl,
  author       = "Jeffrey~B. Layton",
  title        = "From Pixels to Peta{FLOPS}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 8,
  pages        = "32--36",
  month        = aug,
  keywords     = "gups, performance, clusters",
  abstract     = "Learn how graphics processing units are pushing the HPC
    envelope.",
  location     = "http://www.linux-mag.com/id/4543/"
}

@Article{fap,
  author       = "Martin Streicher",
  title        = "Flex and {PHP}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 8,
  pages        = "38--41",
  month        = aug,
  keywords     = "web aplications, flex, ",
  abstract     = "Flex and PHP builds highly-interactive, media-rich and
    Internet-connected applications that can run in every Web browser. ",  
  location     = "http://www.linux-mag.com/id/4062/"
}

@Article{tod,
  author       = "Roderick~W. Smith",
  title        = "The Other Desktop",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 8,
  pages        = "42--45",
  month        = aug,
  keywords     = "xfce, desktops, x11, configuration, applets",
  abstract     = "One of Linux's greatest strengths is that it's easily
    customized.  Although most distributions ship with a variety of standard
    tools for specific purposes (such as sendmail as a mail server or Vixie
    Cron to handle repeated jobs), alternative tools are readily available.
    You can rip out just about any component, either removing it entirely or
    replacing it with something else.  Linux lets you remove or replace more
    components than most operating systems, allowing the savvy administrator to
    customize a Linux installation for specific purposes.", 
  location     = "www.linux-mag.com/id/4404/"
}

@Article{rawd,
  author       = "Jeremy Garcia",
  title        = "Remote Administration with {\tt dsh}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "12",
  month        = jul,
  keywords     = "remote administration, dsh",
  abstract     = "Discover dsh, a utility to run arbitrary commands on any 
    number of remote machines.",
  location     = "http://www.linux-mag.com/id/3926/"
}

@Article{dmwlpo,
  author       = "Jerry Peek",
  title        = "Doimg More with {\tt less}, Part One",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "16--18",
  month        = jul,
  keywords     = "text processing, text viewing",
  abstract     = "Developer Mark Nudelman has been working on less since
    version less-1, released in 1985.  This month, let's cover the Linux
    version less-394 (yes, it's the 394th version), but you can also get less
    for other operating systems, including Mac OS X and Microsoft Windows —
    which makes it a great cross-platform choice for exploring files and
    viewing data from pipes.", 
  location     = "http://www.linux-mag.com/id/4145/"
}

@Article{rywwv,
  author       = "Jason Perlow",
  title        = "Run Your {Windows} with {VMWare}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "20--23",
  month        = jul,
  keywords     = "hardware profiles, virtual machines, ",
  abstract     = "If you already have a Windows PC, you can install Linux and
    run your existing Windows configuration as a virtual machine.  Jason Perlow
    explains how to do it.", 
  location     = "http://www.linux-mag.com/id/4150/"
}

@Article{moplk,
  author       = "Luke Kanies",
  title        = "Master of Puppet",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "24--28, 52",
  month        = jul,
  keywords     = "resources, customization, naming, templates, types, ",
  abstract     = "Want to build a better network? Start by building better
    administration tools.  Puppet aims to spark a new generation of monitoring
    software.", 
  location     = "http://www.linux-mag.com/id/4141/"
}

@Article{dhgayrn,
  author       = "Reboert~G. Brown",
  title        = "{DieHarder}: How Good are your Random Numbers?",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "30--34",
  month        = jul,
  keywords     = "nist, randomness tests, random number generators",
  abstract     = "Simulations, games, encryption, and statistical analyses all
    need random numbers.  But just how random is your random number generator?
    DieHarder can help.", 
  location     = "http://www.linux-mag.com/id/4125/"
}

@Article{kawetb,
  author       = "Tarus Balog",
  title        = "Keep a Watchful Eye",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "36--39, 51",
  month        = jul,
  keywords     = "events, notifications, opennms, xmpp, data collection
    performance, "
}

@Article{rmwarws,
  author       = "Roderick~W. Smith",
  title        = "Routine Maintenance with {\tt anacron}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "42--44",
  month        = jul,
  keywords     = "anacron, job scheduling, system admin",
  abstract     = "While cron is the classic standby to run routine tasks on a 
    regular basis, it's not quite as useful on systems (like laptops and
    desktops) that may not be powered on when the task is scheduled to run.
    Fortunately, Linux users have anacron to fill the gap left by cron.", 
  location     = "http://www.linux-mag.com/id/4173/"
}

@Article{qpinatunozu,
  author       = "Soren Aalto",
  title        = "{QUORUM}: Prepaid {{I}}nternet at the {{U}}niversity of {{Z}}ululand",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "91--94",
  month        = nov,
  keywords     = "internet access, quotas, squid",
  abstract     = "Using Squid's URL redirection to implement WWW usage
    quotas.", 
  location     = "http://www.linuxjournal.com/article/6214"
}

@Article{utksmi,
  author       = "Greg Kroah-Hartman",
  title        = "Using the kernel security module interface",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "86--90",
  month        = nov,
  keywords     = "root plug, hooks, usb devices, kernel modules",
  abstract     = "Some of today's hottest security projects are using the 2.5
    kernel's LSM technology.  Kernel hacker Greg Kroah-Hartman explains the new
    security framework that will give you an extra layer of protection in the
    future.",
  location     = "http://www.linuxjournal.com/article/6279"
}

@Article{pwppi,
  author       = "Pradeep Padala",
  title        = "Playing with {\tt ptrace}, Part {I}",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "78--85",
  month        = nov,
  keywords     = "ptrace, sys calls, strace, register io, single stepping",
  abstract     = "You might have used strace to see whatsystem calls a program
    makes. strace strace and you'll see it uses the ptrace call. What's that?
    Here's what.",
  location     = "http://www.linuxjournal.com/article/6100"
}

@Article{btddisa,
  author       = "Linda Martindale",
  title        = "Bridging the digital divide in {S}outh {A}frica",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "62--64",
  month        = nov,
  keywords     = "translation, internationalization, openoffice",
  abstract     = "When you have to localize both Mozilla and OpenOffice, do you
    have to teach your translators two sets of tools? No--just use KDE's
    KBabel.",
  location     = "http://www.linuxjournal.com/article/5966"
}

@Article{itip,
  author       = "Olexiy Ye Tykhomyrov",
  title        = "Introduction to internationalization programming",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "52--59",
  month        = nov,
  keywords     = "localization, internationalization, language, coding,
    charsets, ",
  abstract     = "When your software gets new users who prefer a different
    language, what are you going to do? Learn the fundamentals of POSIX locales
    and GNU gettext now, so that you can make your program multilingual
    later.",
  location     = "http://www.linuxjournal.com/article/6176"
}

@Article{ilsfgl,
  author       = "Frederick Noronha",
  title        = "Indian language solutions for {GNU}\slash {L}inux",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "46--51",
  month        = nov,
  keywords     = "internationalization, text-to-speech",
  abstract     = "Some of the hardest languages to support are also some of 
    the most widely spoken.  Here's an overview of the projects to make Linux
    work with the two languages on our cover and more.", 
  location     = "http://www.linuxjournal.com/article/6282"
}

@Article{remiwa,
  author       = "Wayne Marshall",
  title        = "Radio e-mail in {W}est {A}frica",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "38--44",
  month        = nov,
  keywords     = "radio networks, topology, mgetty, ppp, qmail",
  abstract     = "To the users, it looks like regular e-mail.  But behind the 
    scenes, a Linux-based project is using HF radio to move it hundreds of
    kilometers without a wire or even a repeater.", 
  location     = "http://www.linuxjournal.com/article/6299"
}

@Article{ccwl,
  author       = "Steve Rosenbluth and Michael Babcock and David Barrington
    Holt", 
  title        = "Controlling creatures with {L}inux",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "28--35",
  month        = nov,
  keywords     = "motion engine, gui, viewers, puppet clients, sequencing,
    animatronic hardware, ",
  abstract     = "Is that movie character animatronic orcomputer-generated?
    Find out how the same Linux-based system can let oneperson control either
    one.", 
  location     = "http://www.linuxjournal.com/article/6216"
}

@Article{kkmrcitlk,
  author       = "Matteo Pelati",
  title        = "Multicast routing code in the {L}inux kernel",
  journal      = lj,
  year         = 2002,
  number       = 103,
  pages        = "16--21",
  month        = nov,
  keywords     = "multicast, routing",
  location     = "http://www.linuxjournal.com/article/6070"
}

@Article{itcoj,
  author       = "Scott Granneman",
  title        = "In the {C}ockpit of {JetS3t}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "10",
  month        = jun,
  keywords     = "backups, cloud storage"
}

@Article{mamwd,
  author       = "Jerry Peek",
  title        = "Merging and More with {\tt diff3}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  OPTnumber    = 7,
  pages        = "16--18",
  month        = jun,
  keywords     = "diff, unix tools",
  abstract     = "Learn how to use diff3 to compare and merge files.",
  location     = "http://www.linux-mag.com/id/4133/"
}

@Article{tawkcsep,
  author       = "Ken Coar",
  title        = "The {A}pache Way",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 7,
  pages        = "36--39",
  month        = jun,
  keywords     = "software management, project management, scalability"
}

@Article{cxjg,
  author       = "Jeremy Garcia",
  title        = "Controlling {X}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 4,
  pages        = "12",
  month        = apr,
  keywords     = "xsel, clipboard, command-line, xwit, xte, automation",
  abstract     = "This article introduces you to a few lesser known X
    utilities.", 
  location     = "http://www.linux-mag.com/id/3721/"
}

@Article{wstd,
  author       = "Jerry Peek",
  title        = "What's the Diff?",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 4,
  pages        = "18--19, 51",
  month        = apr,
  keywords     = "diff, command-line",
  abstract     = "Get more control over how file differences are found and 
    displayed with some lesser-known options, and other techniques for getting
    the output you need. ",
  location     = "http://www.linux-mag.com/id/7161/"
}

@Article{dtrh,
  author       = "Colin McGregor",
  title        = "Don the {R}ed {H}at",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 4,
  pages        = "24--27",
  month        = apr,
  keywords     = "distros, linux, virtual machines, ",
  abstract     = "Two years in the making, RHEL 5 is finally ready.  The 
    result? With Xen, SELinux, the Red Hat Global File System, and more, Red
    Hat Enterprise Linux 5 raises the bar for commercial Linux.  We break down
    the new features and walk you through creating your first virtual
    machine.",
  location     = "http://www.linux-mag.com/id/2989/"
}

@Article{pwvs,
  author       = "Jason Perlow",
  title        = "Prototyping with {VMware} Server",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 4,
  pages        = "36--40",
  month        = aug,
  keywords     = "virtualization, virtual machines",
  abstract     = "Need a system or two to validate a new architecture? When
    combined with Linux, VMware Server provides a sophisticated and highly
    adaptable infrastructure that allows you to test complex customer
    client-server software configurations on a single machine.", 
  location     = "http://www.linux-mag.com/id/3672/"
}

@Article{lapo,
  author       = "Roderick~W. Smith",
  title        = "{LDAP} Authentication, Part One",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 4,
  pages        = "44--46",
  month        = apr,
  keywords     = "ldap, configuration, keys, certificates",
  abstract     = "LDAP allows you manage users on a network.",
  location     = "http://www.linux-mag.com/id/3722/"
}

@Article{hswx,
  author       = "Randal Schwartz",
  title        = "{HTML} Scraping with {XPath}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 4,
  pages        = "48--51",
  month        = apr,
  keywords     = "perl, html, xpath",
  location     = "http://www.stonehenge.com/merlyn/LinuxMag/col92.html"
}

@Article{bbwj,
  author       = "Scott Granneman",
  title        = "Better Backups with JetS3t",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 5,
  pages        = "10",
  month        = may,
  keywords     = "cloud storage, s3, backup services",
  abstract     = "JetS3t is a better way to do online backups via Amazon.com's
    S3 service -- providing cheap online storage on Amazonâ€™s redundant
    servers.",
  location     = "http://www.linux-mag.com/id/3724/"
}

@Article{bwrjg,
  author       = "Jeremy Garcia",
  title        = "Backups with rsnapshot",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 5,
  pages        = "12",
  month        = may,
  keywords     = "backups, cron",
  abstract     = "Even a rudimentary repository system is better than none. 
    Learn how to create local and remote filesystem snapshots with rsnapshot.",
  location     = "http://www.linux-mag.com/id/3725/"
}

@Article{samjp,
  author       = "Jerry Peek",
  title        = "{\tt sdiff} and More",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 5,
  pages        = "16--17, 52",
  month        = may,
  keywords     = "file differences, gnu",
  abstract     = "More on GNU diffutils.  A look into sdiff, which shows file
    comparisons side-by-side and lets you merge two files interactively.",
  location     = "http://www.linux-mag.com/id/3723/"
}

@Article{batsrc,
  author       = "Jason Perlow",
  title        = "Backups and the System Rescue {CD}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 5,
  pages        = "18--21, 53",
  month        = may,
  keywords     = "system rescue, system management, partitions",
  abstract     = "Use the bootable System Rescue CD two or four times per month
    to save your data and protect your sanity.",
  location     = "http://www.linux-mag.com/id/3357/"
}

@Article{tawkcmay,
  author       = "Ken Coar",
  title        = "The Apache Way",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 5,
  pages        = "36--39",
  month        = may,
  keywords     = "software management, project management, project incubation"
}

@Article{lapt,
  author       = "Roderick~W. Smith",
  title        = "LDAp Authentication, Part Two",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 5,
  pages        = "44--46",
  month        = may,
  keywords     = "ldif, account management",
  abstract     = "Managing users on a network is a whole lot simpler with LDAP.
    Part Two: loading your server with account information.",
  location     = "http://www.linux-mag.com/id/4124/"
}

@Article{tujp,
  author       = "Jason Perlow",
  title        = "Tweaking {U}buntu",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 12,
  pages        = "18--19, 52",
  month        = dec,
  keywords     = "software repositories, ubuntu, customization",
  abstract     = "Ubuntu is the best Linux distro out there. Here’s how to make
    it even better.",
  location     = "http://www.linux-mag.com/id/2782/"
}

@Article{lisv,
  author       = "Sreekrishnan Venkateswaran",
  title        = "Linux Infrared",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 12,
  pages        = "20--23, 53",
  month        = dec,
  keywords     = "infrared interfaces, device drivers, "
}

@Article{tbobw,
  author       = "Philippe Cohen and Miguel {de Icaza}",
  title        = "The Best of Both Worlds",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 12,
  pages        = "30--33",
  month        = dec,
  keywords     = "mono"
}

@Article{pprws,
  author       = "Roderick~W.Smith",
  title        = "Powerful {P}ortage",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 12,
  pages        = "46--47, 54",
  month        = dec,
  keywords     = "portage, package management, gentoo",
  abstract     = "Discover how to use Gentoo’s package management tools.",
  location     = "http://www.linux-mag.com/id/3130/"
}

@Article{usdpo,
  author       = "Sreekishnan Venkateswaran",
  title        = "User Space Drivers, Part One",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 2,
  pages        = "22--25",
  month        = feb,
  keywords     = "response times, drivers, io regions, memory registers"
}

@Article{uirws,
  author       = "Roderick~W. Smith",
  title        = "Using {\tt initrd}",
  journal      = lmag,
  year         = 2007,
  volume       = 9,
  number       = 2,
  pages        = "46--48",
  month        = feb,
  keywords     = "system boot",
  abstract     = "Learn how to add boot options and gain flexibility via an
    initial RAM disk.", 
  location     = "http://www.linux-mag.com/id/3303/"
}

@Article{ukak,
  author       = "Sreekishnan Venkateswaran",
  title        = "Using {\tt kexec} and {\tt kdump}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 10,
  pages        = "22--26",
  month        = oct,
  keywords     = "system hacking",
  abstract     = "Kexec can spawn a kernel-over-a-kernel without the overhead
    of boot firmware, while kdump can reliably collect a crash-dump using the
    services of kexec.",
  location     = "http://www.linux-mag.com/id/2998/"
}

@Article{msosp,
  author       = "Ken Hess",
  title        = "Making Sense of System Performance",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 10,
  pages        = "40--43, 53",
  month        = oct,
  keywords     = "i/o, system reports, sysstat, system management",
  abstract     = "Old-fashioned tools can prevent modern problems.", 
  location     = "http://www.linux-mag.com/id/2953/"
}

@Article{fcrws,
  author       = "Roderick~W. Smith",
  title        = "Fall Cleaning",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 10,
  pages        = "50--53",
  month        = oct,
  keywords     = "system maintenance, disk space"
}

@Article{bwxaw,
  author       = "Jason Perlow",
  title        = "Blog With {XAMPP} and {WordPress}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 11,
  pages        = "18--20",
  month        = nov,
  keywords     = "blogging, instant messaging",
  abstract     = "Want to blog? Grab XAMPP and WordPress and just add prose!",
  location     = "http://www.linux-mag.com/id/2598/"
}

@Article{lbsv,
  author       = "Sreekishnan Venkateswaran",
  title        = "Linux  {Bluetooth}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 11,
  pages        = "22--25, 60",
  month        = nov,
  keywords     = "bluetooth, device drivers, network protocols"
}

@Article{pttlsb,
  author       = "Martin Streicher",
  title        = "Porting to the {L}inux {S}tandard {B}ase",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 11,
  pages        = "32--43",
  month        = nov,
  keywords     = "consistency, interoperability, virtual machines"
}

@Article{murws,
  author       = "Roderick~W. Smith",
  title        = "Mastering {\tt udev}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 11,
  pages        = "50--53",
  month        = nov,
  keywords     = "udev, device management",
  abstract     = "Learn how to use dynamic device files in Linux.",
  location     = "http://www.linux-mag.com/id/3015/"
}

@Article{aaital,
  author       = "Michale Swaine",
  title        = "Apple and {I}ntel: Together At Last",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "16--19",
  month        = nov,
  keywords     = "machinations, osx, portability",
  abstract     = "A year after announcing the move to Intel processors, Apple
    has completed the transition—there's not a non-Intel Mac in the lineup.  So
    what does this shift mean for developers?",
  location     = "http://www.drdobbs.com/architecture-and-design/apple-and-intel-together-at-last/193104363"
}

@Article{sswdc,
  author       = "Robert~W. Anderson and Daniel Ciruli",
  title        = "Scaling {SOA} with Distributed Computing",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "22--26",
  month        = nov,
  keywords     = "soa, scalability, grid computations",
  abstract     = "Scalability is critical when designing Service-Oriented
    Architectures", 
  location     = "http://www.drdobbs.com/article/print?articleId=193104809&siteSectionName="
}

@Article{dutps,
  author       = "Pablo Santos and Francisco~J. Garcia",
  title        = "Distributed Unit Testing",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "28--32",
  month        = nov,
  keywords     = "automated tests, synchronization",
  abstract     = "There's only one way to accurately and efficiently support
    multiple platform combinations—testing, and lots of it.",
  location     = "http://www.drdobbs.com/tools/distributed-unit-testing/193104810"
}

@Article{fdtmjc,
  author       = "Jeff Cahoon",
  title        = "Faster Development Through Modeling",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "34--41",
  month        = nov,
  keywords     = "software development, code reuse, modeling",
  abstract     = "Jeff describes a modeling technique that uses free tools and
    Model-Driven Architecture processes to speed up development.",
  location     = "http://www.drdobbs.com/architecture-and-design/faster-development-through-modeling/193104822"
}

@Article{i3mimjd,
  author       = "Tom Thompson",
  title        = "Importing {3D} models into Mobile {J}ava Devices",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "42--50",
  month        = nov,
  keywords     = "key classes, rendering models",
  abstract     = "Here's a step-by-step guide for importing 3D models from PCs
    into cell phones.", 
  location     = "http://www.drdobbs.com/mobile/importing-3d-models-into-mobile-java-dev/193104855"
}

@Article{aaotf,
  author       = "Drew Wildner",
  title        = "Automating Applications On-The-Fly",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "52--57",
  month        = nov,
  keywords     = "pdf generation, web services",
  abstract     = "Third-party tools, C#, and Visual Studio 2005 can take the
    pain out of generating PDF content in ASP.NET.",
  location     = "http://www.drdobbs.com/windows/automating-applications-on-the-fly/193104870"
}

@Article{cfds,
  author       = "Diomidis Spinellis",
  title        = "Code Finessing",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "58--63",
  month        = nov,
  keywords     = "c preprocessor, functional coding, software development",
  abstract     = "When it comes down to it, what counts is quality code that is
    correct, readable, and efficient.",
  location     = "http://www.drdobbs.com/open-source/code-finessing/193104882"
}

@Article{antrp,
  author       = "Ethan~Q. McCallum",
  title        = "{APR} Networking \& the {R}eactor {P}attern",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "64--70",
  month        = nov,
  keywords     = "socket programming, time service, polling, ",
  abstract     = "The Apache Portable Runtime is a C-based API that provides
    abstractions ranging from memory management to telling time.",
  location     = "http://www.drdobbs.com/cpp/apr-networking-the-reactor-pattern/193101548"
}

@Article{wdm,
  author       = "Scott~W. Ambler",
  title        = "Whence Data Management?",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 11,
  pages        = "79--83",
  month        = nov,
  keywords     = "data quality, agile database techniques",
  abstract     = "Scott reports on his recent Data Management survey.  You'll
    be surprised by the results.  Lots of companies have a data group, but much
    of the time, they aren't being used effectively.", 
  location     = "http://www.drdobbs.com/architecture-and-design/whence-data-management/193104893"
}

@Article{kpsk,
  author       = "Sreekishnan Venkateswaran",
  title        = "Kernel Probes",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 9,
  pages        = "20--23, 52",
  month        = sep,
  keywords     = "kprobes, jprobes, return probes"
}

@Article{tjfs,
  author       = "Steve Best",
  title        = "Tuning Journaling File Systems",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 9,
  pages        = "28--33",
  month        = sep,
  keywords     = "access times, io performance, system tuning, file systems",
  abstract     = "You can improve the performance of journaling file systems by
    taking the time to tune them.  There has been considerable effort placed in
    the designs to make the file systems scalable and fast without significant
    expertise.  Just twisting a few knobs — mount options and placing the
    journal on an external device — can make the journaling file systems run
    significantly faster.", 
  location     = "http://www.linux-mag.com/id/2927/"
}

@Article{c,
  author       = "Tanner Lovelace",
  title        = "{CA Cert}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 9,
  pages        = "34--37",
  month        = sep,
  keywords     = "certificate authority, security, ssl, client certificates",
  abstract     = "Learn how to create server and client SSL certificates using
    the free CACert certificate authority. ", 
  location     = "http://www.linux-mag.com/id/2926/"
}

@Article{ylrws,
  author       = "Roderick~W. Smith",
  title        = "Yummy {L}inux",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 9,
  pages        = "44--46",
  month        = sep,
  keywords     = "yum, package management, system administration"
}

@Article{smaoocmfps,
  author       = "Eshrat Arjomandi and William~G. O'Farrell and Gregory V. Wilson",
  title        = "Smart Messages: An Object-Oriented Communication Mechanism for Parallel Systems",
  journal      = cs,
  year         = 1996,
  volume       = 9,
  number       = 4,
  pages        = "313--329",
  month        = "Fall",
  keywords     = "smart messages, marshaling data, active objects, remote
    invocation, futures, synchronization",
  abstract     = "ABC++ is a portable object-oriented type-safe class library
    for parallel programming in C++.  It supports active objects, synchronous
    and asynchronous object interactions, and object-based shared regions on
    both shared- and distributed-memory parallel computers.  ABC++ is written
    in, and compatible with, standard C++ : no language extensions or
    pre-processors are used.  This paper focuses on its use of an
    object-oriented technique called smart messages to support object
    interactions.  Smart messages demonstrate the effectiveness of
    object-oriented programming in encapsulating low-level details of
    concurrency and in improving software portability.", 
  location     = "http://www.usenix.org/publications/compsystems/1996/fall_arjomandi.pdf"
}

@Article{iptjp,
  author       = "Jerry Peek",
  title        = "{ImageMagick}, Part Two",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 7,
  pages        = "16--17, 53",
  month        = jul,
  keywords     = "image data, file formats, image resizing"
}

@Article{ptivs,
  author       = "Sreekishnan Venkateswaran",
  title        = "Pardon the Interruption",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 7,
  pages        = "24--27",
  month        = jul,
  keywords     = "interrupt context, irqs, interrupt handlers, softirqs,
    tasklets",
  abstract     = "Interrupt handlers are an integral part of most device
    drivers. Learn to implement interrupt handlers and bottom halves.",
  location     = "http://www.linux-mag.com/id/2639/"
}

@Article{rssde,
  author       = "Scott~D. Epter",
  title        = "Redundant Schmedundant",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 7,
  pages        = "28--29, 54",
  month        = jul,
  keywords     = "availability, frequency, duration"
}

@Article{ctcpbs,
  author       = "Tanner Lovelace",
  title        = "{\tt cmake}: The Cross Platform Build System",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 7,
  pages        = "30--33",
  month        = jul,
  keywords     = "cmake, projects, build systems, macros",
  abstract     = "cmake is a portable build system: Create a single source
    definition and build your code on one or many platforms.  Learn how to use
    cmake and see how KDE uses the tool for the project’s next generation build
    system.", 
  location     = "http://www.linux-mag.com/id/2667/"
}

@Article{tldm,
  author       = "Sreekishnan Venkateswaran",
  title        = "The {L}inux Device Model",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 7,
  pages        = "24--27, 60",
  month        = jul,
  keywords     = "kobjects, sysfs, device classes, udev, device management,
  device bus, hot pluging, microcode",
  abstract     = "Many Linux subsystems, such as the /dev filesystem, hotplug,
    module autoload, and microcode download have undergone significant changes
    with the introduction of the new device model.  Learn about udev, sysfs,
    kobjects, classes, and more.", 
  location     = "http://www.linux-mag.com/id/2617/"
}

@Article{mpal,
  author       = "David Rivas",
  title        = "Mobile Phones and {L}inux",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 7,
  pages        = "28--31, 61",
  month        = jul,
  keywords     = "symbian, mobile systems, palm",
  abstract     = "Yes, Linux is now powering a number of brand name mobile
    phones, but there’s a great deal yet to do to transform Linux into a
    credible alternative to proprietary mobile operating systems.  Here’s a
    look at the challenges ahead-- and a dark horse entering the mobile race
    this month.", 
  location     = "http://www.linux-mag.com/id/2575/"
}

@Article{tupots,
  author       = "Ben Chelf",
  title        = "The Undeniable Power of the Source",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 8,
  pages        = "32--35",
  month        = aug,
  keywords     = "security, secure programming, security audits",
  abstract     = "People generally consider the code that powers the Linux
    kernel and other open source packages to be both superlative and secure
    because “many eyes make all bugs shallow.” But even the most reliable open
    source packages are still burdened with security flaws.  Why? To find the
    answer, you have to look at the source.", 
  location     = "http://www.linux-mag.com/id/2615/"
}

@Article{banids,
  author       = "Ronald McCarty",
  title        = "Bro:  {A} Network Intrusion Detection System",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 8,
  pages        = "36--39",
  month        = aug,
  keywords     = "termcap, intrusion detection",
  abstract     = "Intrusion detection is critical for network security.  Use
    Bro to catch miscreants red-handed.",
  location     = "http://www.linux-mag.com/id/2611/"
}

@Article{oslms,
  author       = "Martin Streicher",
  title        = "Open Source Licensing",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 8,
  pages        = "40--44",
  month        = aug,
  keywords     = "software licensing, software development, law"
}

@Article{ltfrws,
  author       = "Roderick~W. Smith",
  title        = "Lighting the {FUSE}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 8,
  pages        = "52--54",
  month        = aug,
  keywords     = "user-space file systems",
  abstract     = "Explore unusual filesystems support in Linux.",
  location     = "http://www.linux-mag.com/id/2566/"
}

@Article{aasoacaetods,
  author       = "Jon Louis Bentley and Mary Shaw",
  title        = "An {A}lphard Specification of a Correct and Efficient Transformation on Data Structures", 
  journal      = tse,
  year         = 1980,
  volume       = 6,
  number       = 6,
  pages        = "572--584",
  month        = nov,
  keywords     = "searching, data structures transformations, representations",
  abstract     = "In this paper we study the problem of designing and 
    specifying standard program components applicable to a wide variety of
    tasks; we choose for this study the specific problem domain of data
    structures for general searching problems.  Within this domain Bentley and
    Saxe [1] have developed transformations for converting solutions of simple
    searching problems to solutions of more complex problems.  We discuss one
    of those transformations, specify precisely the transformation and its
    conditions of applicability, and prove its correctness; we accomplish this
    by casting it in terms of abstract data types-specifically by using the
    Alphard form mechanism.  The costs of the structures derived by this
    transformation are only slightly greater than the costs of the original
    structures, and the correctness of the transformation definition together
    with the correctness of the original structure assure the correctness of
    the derived structure.  The transformation we describe has already been
    used to develop a number of new algorithms, and it represents a new level
    of generality in software engineering tools.", 
  location     = "http://dx.doi.org/10.1109/TSE.1980.234506"
}

@Article{dmfwi,
  author       = "Jiawei Han and Kevin Chang",
  title        = "Data Mining for {W}eb Intelligence",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "64--70",
  month        = nov,
  keywords     = "data mining, web mining",
  abstract     = "Searching, comprehending, and using the semi-structured HTML,
    XML, and database-service-engine information stored on the Web poses a
    significant challenge: This data is more sophisticated and dynamic than the
    information commercial database systems store.  To supplement keyword based
    indexing, researchers have applied data mining to Web page ranking.  In
    this context, data mining helps Web search engines find high-quality Web
    pages and enhances Web click stream analysis.  For the Web to reach its
    full potential, however, we must improve its services, make it more
    comprehensible, and increase its usability.  As researchers continue to
    develop data mining techniques, the authors believe this technology will
    play an increasingly important role in meeting the challenges of developing
    the intelligent Web.Ultimately, data mining for Web intelligence will make
    the Web a richer, friendlier, and more intelligent resource that we can all
    share and explore.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1046977"
}

@Article{iatwolae,
  author       = "Michele Missikof and Roberto Navigli and Paola Velardi",
  title        = "Integrated Approach to {W}eb Ontology Learning and Engineering",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "60--63",
  month        = nov,
  keywords     = "ontology engineering, semantic interpretation",
  abstract     = "Developing the semantic Web-seeking to improve the semantic
    awareness of computers connected via the Internet-requires a systematic,
    computer-oriented world representation.  Researchers often refer to such a
    model as an ontology.Despite the work done on them in recent years,
    ontologies have yet to be widely applied and used.  Research has devoted
    only limited attention to such practical issues as techniques and tools
    aimed at an ontology's actual construction and content.A software
    environment, centered around the OntoLearn tool, can build and assess a
    domain ontology for intelligent information integration within a virtual
    user community.  OntoLearn has already been tested in two European
    projects, where it functioned as the basis for a semantic interoperability
    platform used by small and medium-sized tourism enterprises.  Further,
    developers can easily adapt OntoLearn to work with other general-purpose
    ontologies.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1046977"
}

@Article{obkm,
  author       = "Dieter Fensel",
  title        = "Ontology-Based Knowledge Management",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "56--59",
  month        = nov,
  keywords     = "architecture, extraction, representation",
  abstract     = "The Web's very popularity is making it more difficult to 
    find, present, and maintain the data that users with a wide range of tasks
    and computer skills need.  Existing document management systems use keyword
    matching as a search method, combined with information retrieval rather
    than query answering.  In addition, these systems offer limited
    information-sharing facilities, and they don't support different views on
    documents or information maintenance.To address these weaknesses, a
    European consortium formed the On-to-Knowledge Project to build an ontology
    based tool suite that efficiently processes the many heterogeneous,
    distributed, and semi-structured documents typically found in intranets and
    on the Web.  The consortium's approach integrates semantic Web search
    technology, document exchange via transformation operators,automated
    information extraction, and systematic support for information maintenance
    and user specific views.  On-to-Knowledge's tools exploit the power of
    ontologies to provide automated support for acquiring, maintaining, and
    accessing weakly structured information sources.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1046975"
}

@Article{tbiitsw,
  author       = "Joanna Bryson and David Martin and Sheila McIlraith and Lynn
    Stein", 
  title        = "Toward Behavioral Intelligence in the {S}emantic {W}eb",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "48--54",
  month        = nov,
  keywords     = "distributed intelligence, web agents, module coordination,
    reactive plans, service descriptions",
  abstract     = "Realizing the Web's full potential will require the
    development and support of agents that function as schedulers, planners,
    and searchers who, with minimal direction, can serve as an omnipresent
    staff of advisers, secretaries, brokers, and research assistants.
    Electronic commerce has brought this capability tantalizingly near.
    Organizations and individuals have connected an enormous variety of
    products and services to the Internet, making them accessible to other
    programs through simple communication protocols.Now the AI community must
    determine how it can build intelligent agents to exploit these services.
    One strategy would change the Web itself, making it accessible to existing
    AI modeling and reasoning techniques.  In this semantic Web, service and
    content providers would mark pages in accordance with standardized
    conventions designed to reduce ambiguity and make automated reasoning
    easier.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1046974"
}

@Article{qasdlfia,
  author       = "Toru Ishida",
  title        = "{Q}: {A} Scenario Description Language for Interactive Agents",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "42--47",
  month        = nov,
  keywords     = "scenarios, guarded commands, agants, avatars, design
    process", 
  abstract     = "Agent internal mechanisms form the basis for many of the 
    languages proposed for describing agent behavior and inter-agent protocols.
    For the Web, however, we should also consider the needs of application
    designers such as sales managers, travel agents, and schoolteachers.To this
    end, the author is developing Q, a language for describing interaction
    scenarios between agents and users based on agent external roles.  Q also
    provides an interface between computing professionals and scenario writers.
    Rather than depending on agent internal mechanisms, Q seeks to describe how
    scenario writers should request that agents behave.  Scenarios help
    establish a bridge between the computing professionals who design agents
    and the scenario writers who design applications.  Thus, we can expect an
    effective dialog to emerge from the interplay between the two different
    perspectives during the process of formalizing interaction patterns.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1046973"
}

@Article{sidftw,
  author       = "Toyoaki Nishida",
  title        = "Social Intelligence Design for the {W}eb",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "37--41",
  month        = nov,
  keywords     = "social context, embodied conversational agents, collaboration
    design, public discourse, social intelligence",
  abstract     = "Web intelligence reflects the view that eventually we will
    build a totally new kind of collective intelligence on the Web computing
    infrastructure.  To reach this goal we must solve several major problems.
    For example, embedding Web computing into our everyday lives and society
    poses a more difficult problem than engineers might think.  Because new
    technologies often consume financial resources without providing a
    comparable benefit, we must pay close attention to the social aspects of
    intelligence and how Web computing can augment knowledge processes, an
    attitude that underlies social intelligence design.Computer-supported
    collaborative work takes a similar approach, focusing on well-structured,
    goal-oriented groups.  Social intelligence design, on the other hand,
    highlights collective knowledge processes in informal, loosely coupled
    groups.  It thus focuses not only on technological development for Web
    intelligence but also on the design and analysis of a social framework for
    embedding Web intelligence into everyday life.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1046972"
}

@Article{twasn,
  author       = "Ravi Kumar and Prabhakar Raghavan and Sridhar Rajagopalan and
    Andrew Tomkins", 
  title        = "The {W}eb and Social Networks",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "32--36",
  month        = nov,
  keywords     = "hits algorithm, link analysis, page ranking, community
  patterns, web diameter, fractal structures",
  abstract     = "The sheer volume of Web data, together with its low 
    signal-to-noise ratio, make it difficult for text-based search engines to
    locate high-quality pages.  Analyzing the links between Web sites has
    dramatically improved the Web search experience and spawned research into
    the Web's link structure.  This research includes graph-theoretic studies
    of connectivity, which have shown the Web to have strong similarities with
    social networks.Self-similarity is pervasive in social networks.  While
    researchers have observed Web self-similarity in other contexts, finding a
    fractal structure in a graph-theoretic setting adds further evidence to the
    Web's small-world social nature.  Thus, researchers seek to explain and
    exploit the human behavior implicit in the Web's evolving structure.How can
    we combine the power of Web networks with networks resulting from other
    human activity? Accomplishing this goal represents knowledge management's
    key challenge and opportunity.", 
  location     = "http://dx.doi.org/10.1109/MC.2002.1046971"
}

@Article{fcitwi,
  author       = "Nick Cercone and Lijun Hou and Vlado Keselj and Aijun An and
    Kanlaya Naruedomkul and Xiaohua  Hu",
  title        = "From Computational Intelligence to {W}eb Intelligence",
  journal      = ieeec,
  year         = 2002,
  volume       = 35,
  number       = 11,
  pages        = "72--76",
  month        = nov,
  keywords     = "natural language interfaces, metasearch extensions, machine
    translations, machine learning, agent systems", 
  abstract     = "Systems that can communicate naturally and learn from
    interactions will power Web intelligence's long term success.  The large
    number of problems requiring Web specific solutions demand a sustained and
    complementary effort to advance fundamental machine learning research and
    incorporate a learning component into every Internet
    interaction.Traditional forms of machine translation either translate
    poorly, require resources that grow exponentially with the number of
    languages translated, or simplify language excessively.  Recent success in
    statistical, non-linguistic, and hybrid machine translation suggests that
    systems based on these technologies can achieve better results with a large
    annotated language corpus.Adapting existing computational intelligence
    solutions, when appropriate for Web intelligence applications, must
    incorporate a robust notion of learning that will scale to the Web, adapt
    to individual user requirements, and personalize interfaces.",
  location     = "http://dx.doi.org/10.1109/MC.2002.1046979"
}

@Article{wfskceafm,
  author       = "Darren Abramson and Lee Pike",
  title        = "When Formal Systems Kill:  Computer Ethics and Formal Methods",
  journal      = "The APA Newsletter on Philosophy and Computers",
  year         = 2011,
  volume       = 11,
  number       = 1,
  month        = "Fall",
  keywords     = "ethics, formal methods, requirement specifications,
    intellectual property",
  abstract     = "Computer ethics is usually motivated by and deals with
    problematic decision-making cases arising from the ubiquity and
    unprecedented power of computer and information technologies.  In this
    paper, we address a distinct topic that is germane to computer ethics but
    has thus far been neglected in the computer ethics literature.  Formal
    methods is the science of mathematically proving computer systems correct.
    Formal methods are motivated by the need for safety-critical systems (e.g.,
    autopilot systems) that must be bug-free.  We begin by describing the
    automatic formal system property of computers.  This property has been
    studied by cognitive scientists, but it has yet to be addressed by computer
    ethicists, despite it having significant ethical ramifications,
    particularly with respect to formal methods.  After introducing the history
    and purview of formal methods, we argue that normative questions about
    formal methods are the purview of computer ethics.  Nevertheless, we take
    the position in this paper that these questions are open questions and do
    not attempt to solve these problems here.", 
  location     = "http://www.cs.indiana.edu/~lepike/pubs/fm-ethics.pdf"
}

@Article{aewtsa,
  author       = "Scott Granneman",
  title        = "An Easier Way to Set {ACL}s",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 6,
  pages        = "10",
  month        = jun,
  keywords     = "acls, file systems, shell commands",
  abstract     = "Facilitate fine-grained file permissions with ACL editor
    Eiciel.", 
  location     = "http://www.linux-mag.com/id/2735/"
}

@Article{ipojp,
  author       = "Jerry Peek",
  title        = "{ImageMagick}, Part One",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 6,
  pages        = "14--16",
  month        = jun,
  keywords     = "image processing, format conversion, image composites, ",
  abstract     = "ImageMagick is a package of tools for creating and editing
    images that’s not easy to get started with, but is well worth the effort.
    Here’s an introduction, just in time for processing those summer photos.",
  location     = "http://www.linux-mag.com/id/2561/"
}

@Article{kbsv,
  author       = "Sreekishnan Venkateswaran",
  title        = "Kernel Boot",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 6,
  pages        = "26--29",
  month        = jun,
  keywords     = "bios, memory management, bogomips",
  abstract     = "Look at messages generated during kernel boot and explore the
    internals of the more interesting ones. ",
  location     = "http://www.linux-mag.com/id/2671/"
}

@Article{pilsb,
  author       = "Steve Best",
  title        = "Peering into {L}inux",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 6,
  pages        = "30--33",
  month        = jun,
  keywords     = "system tracing, systemtap, probes, ",
  abstract     = "How to find Linux performance problems using SystemTAP.",
  location     = "http://www.linux-mag.com/id/2555/"
}

@Article{cwg,
  author       = "Jon Loeliger",
  title        = "Collaborating With {G}it",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 6,
  pages        = "34--37, 57",
  month        = jun,
  keywords     = "branches, cloning, repositories, "
}

@Article{bpop,
  author       = "Roderick~W. Smith",
  title        = "Backup, Part One: Preparation",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 6,
  pages        = "52--53, 58",
  month        = jun,
  keywords     = "back up, tape, optical media, network backup",
  abstract     = "Don’t put off backups. Here’s how to plan a Linux backup
    strategy.", 
  location     = "http://www.linux-mag.com/id/2685/"
}

@Article{mymwf,
  author       = "Scott Granneman",
  title        = "Map Your Mind With {FreeMind}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 2,
  pages        = "12",
  month        = feb,
  keywords     = "mind maps, conceptual mapping",
  abstract     = "Map your ideas and thoughts with FreeMind.",
  location     = "http://www.linux-mag.com/id/2435/"
}

@Article{wsgpfs,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part Five: {\tt sort}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 2,
  pages        = "16--19",
  month        = feb,
  keywords     = "fields, sorting, command-line numeric sorting",
  abstract     = "For decades, sort has been extended over and over again to 
    make it more and more useful.  Here’s the fifth in an ongoing series about
    new features in familiar utilities.", 
  location     = "http://www.jpeek.com/articles/linuxmag/2006-02/"
}

@Article{dmlpt,
  author       = "Sreekishnan Venkateswaran",
  title        = "Down Memory Lane, Part Two",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 2,
  pages        = "26--30",
  month        = feb,
  keywords     = "physical memory, page management, ecc memory, cmos",
  abstract     = "Learn how the kernel views physical memory.",
  location     = "http://www.linux-mag.com/id/2451/"
}

@Article{sbcd,
  author       = "Christopher Diggins",
  title        = "Something Borrowed",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 2,
  pages        = "44--47",
  month        = feb,
  keywords     = "code search, search engines"
}

@Article{citk,
  author       = "Sreekishnan Venkateswaran",
  title        = "Concurrency in the Kernel",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 11,
  pages        = "20--26",
  month        = nov,
  keywords     = "spinlocks, semaphores, atomicity, reader-writer locks",
  abstract     = "Multiple threads of execution need to be synchronized to
    avoid data corruption and even system freezes.",
  location     = "http://www.linux-mag.com/id/2316/"
}

@Article{lwsnpo,
  author       = "Forrest Hoffman",
  title        = "Logging with syslog-ng, Part One",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 11,
  pages        = "50--54, 63",
  month        = nov,
  keywords     = "syslogd, logging, log collections, log servers",
  abstract     = "If you need to monitor and manage such a configuration, try
    syslog-ng (syslog, next generation), a drop-in replacement for syslogd.
    syslog-ng provides more sophisticated log management capabilities and
    enables log transfers over the Internet.", 
  location     = "http://www.linux-mag.com/id/2308/"
}

@Article{idprws,
  author       = "Roderick~W. Smith",
  title        = "Improving Disk Performance",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 11,
  pages        = "56--58",
  month        = nov,
  keywords     = "disk performance, disk access modes, filesystems, filesystem
    layout", 
  abstract     = "How to get the most out of your hard disks.",
  location     = "http://www.linux-mag.com/id/2318/"
}

@Article{sofjg,
  author       = "Jeremy Garcia",
  title        = "See Open Files",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 1,
  pages        = "16",
  month        = jan,
  keywords     = "lsof, system administration",
  abstract     = "Learn how to use lsof to see what files are open on your
    system. ", 
  location     = "http://www.linux-mag.com/id/2412/"
}

@Article{wsgpf,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part Four",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 1,
  pages        = "18--21, 62",
  month        = jan,
  keywords     = "filename matching, matching timestamps, directory control,
    text output, find",
  abstract     = "Since find(1) came into being decades ago, programmers have
    been adding new features.  Here's the fourth of a series about some of
    those.",
  location     = "http://www.linux-mag.com/id/6981/"
}

@Article{dmlpo,
  author       = "Sreekishnan Venkateswaran",
  title        = "Down Memory Lane, Part One",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 1,
  pages        = "28--31",
  month        = jan,
  keywords     = "memory subsystem, traps, chip drivers, flash filesystems",
  abstract     = "Most embedded devices boot from flash memory and have data
    resident on flash-based storage.  Here’s how to use flash devices while
    embedding Linux.",
  location     = "http://www.linux-mag.com/id/2400/"
}

@Article{g40mm,
  author       = "Mark Mitchell",
  title        = "{GCC} 4.0",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 1,
  pages        = "32--37",
  month        = jan,
  keywords     = "optimization, compilers, rtl, gcc, ssa form",
  abstract     = "GCC 4.0 has a new optimization infrastructure, and future
    versions of GCC will realize even more performance improvements.  Here’s an
    overview of what’s new and what’s to come.", 
  location     = "http://www.linux-mag.com/id/2394/"
}

@Article{ebfwg,
  author       = "William Nagel",
  title        = "Exterminate Bugs Faster with {GDB}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 1,
  pages        = "38--42",
  month        = jan,
  keywords     = "debugging, automation",
  abstract     = "You’ve used GDB, but are you really getting the most from it?
    These advanced GDB tips will help you debug to your full potential.", 
  location     = "http://www.linux-mag.com/id/2396/"
}

@Article{xact,
  author       = "Roderick~W. Smith",
  title        = "{\tt xinetd} Access Control Tools",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 1,
  pages        = "54--56",
  month        = jan,
  keywords     = "xinetd, ip-based controls, network interface controls,
  temporal controls, client number controls, cpu load controls",
  abstract     = "Here are some helpful tips to enhance xinetd security and
    performance.",
  location     = "http://www.linux-mag.com/id/2402/"
}

@Article{ffsbwb,
  author       = "Scott Granneman",
  title        = "Fight File System Bloat with {B}aobab",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 3,
  pages        = "12",
  month        = mar,
  keywords     = "visualization, system management, file maintenance",
  abstract     = "Find the files that are hogging your hard drive with with
    Baobab.", 
  location     = "http://www.linux-mag.com/id/2468/"
}

@Article{epol,
  author       = "Jeremy Garcia",
  title        = "Enjoying Podcasts on {L}inux",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 3,
  pages        = "14",
  month        = mar,
  keywords     = "podcasting, multimedia",
  abstract     = "Discover how to use bashpodder as a podcatching client.",
  location     = "http://www.linux-mag.com/id/2477/"
}

@Article{wsgpst,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part Six: {\tt tar}",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 3,
  pages        = "16--18",
  month        = mar,
  keywords     = "compressed archives, command-line tools, pathnames, file
    choosing, archiving, file management",
  abstract     = "What’s new with tar since it was written eons ago? A lot. 
    Here’s the sixth of a series about new features of old utilities.",
  location     = "http://www.jpeek.com/articles/linuxmag/2006-03/"
}

@Article{llawq,
  author       = "Sreekishnan Venkateswaran",
  title        = "Linked Lists and Work Queues",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 3,
  pages        = "26--30",
  month        = mar,
  keywords     = "linked lists, hash links, work queues, ",
  abstract     = "The use of standard kernel helper facilities simplifies your
    code, weeds out redundancies from the kernel, and helps long-term
    maintenance.  And since the helpers are bug-free and optimized, you inherit
    those benefits for free.", 
  location     = "http://www.linux-mag.com/id/2518/"
}

@Article{htgi,
  author       = "Jon Loeliger",
  title        = "How to {G}it It",
  journal      = lmag,
  year         = 2006,
  volume       = 8,
  number       = 3,
  pages        = "36--41",
  month        = mar,
  keywords     = "source-code management, distributed version control,
    plumbing, porcelain",
  abstract     = "You've heard about it.  You've read about it.  But maybe you
    just don't *cough* git it yet.  Linus converted to git, now you can too
    with this overview.", 
  location     = "http://www.linux-mag.com/id/2489/"
}

@Article{ulicfsmm,
  author       = "Brian~N. Bershad and Thomas~E. Anderson and
    Edward~D. Lazowska and Henry~M. Levy",
  title        = "User-level interprocess communication for shared memory multiprocessors",
  journal      = tocs,
  year         = 1991,
  volume       = 9,
  number       = 2,
  pages        = "175--198",
  month        = may,
  keywords     = "thread, multiprocessor, operating system, parallel
    programming, performance, communication",
  abstract     = "In large, dynamic, real-time computer systems, it is 
    frequently most cost effective to employ different software performance and
    reliability techniques at different levels of granularity, at different
    times, or within different subsystems.  These techniques may include
    regulation of redundancy and resource allocation, multiversion and
    multipath execution, adjustments of program attributes such as time-out
    periods and others.  The management of software in such systems is a
    difficult task.  Software that may be adapted to meet varying performance
    and reliability requirements offers a solution.  A REal-time Software
    Adaptation System (RESAS) includes a uniform model of adaptable software
    and provides the tool necessary for programmers to implement algorithms
    that choose and enact adaptations in real time.  RESAS has been implemented
    on a testbed consisting of a multiprocessor and an attached workstation,
    and adaptation algorithms have been developed that address the problem of
    adapting software to achieve two goals: software execution within specified
    time constraints and software resiliency with respect to computer hardware
    failures.", 
  location     = "http://dx.doi.org/10.1145/103720.114701"
}

@Article{trhjg,
  author       = "Jeremy Garcia",
  title        = "The Rootkit Hunter",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 9,
  pages        = 18,
  month        = sep,
  keywords     = "security, rootkits",
  abstract     = "Learn how to install and set up Rootkit Hunter, a utility to
    stalk rootkits.",
  location     = "http://www.linux-mag.com/id/2212/"
}

@Article{ktsv,
  author       = "Sreekishnan Venkateswaran",
  title        = "Kernel Threads",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 9,
  pages        = "28--32",
  month        = sep,
  keywords     = "threading, kernels, user mode",
  abstract     = "Kernel threads are used to implement background tasks inside
    the kernel.  They are similar to user processes, but live in kernel address
    space.  Here’s how to use them.", 
  location     = "http://www.linux-mag.com/id/2195/"
}

@Article{eprws,
  author       = "Roderick~W. Smith",
  title        = "Ethereal Power",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 9,
  pages        = "58--60, 67",
  month        = sep,
  keywords     = "packet sniffing, networks, traffic monitoring, data
    analysis, ", 
  abstract     = "See how to use Ethereal to monitor your network’s traffic.",
  location     = "http://www.linux-mag.com/id/2197/"
}

@Article{nsptf,
  author       = "Jerry Peek",
  title        = "New Shells, Part Three: fish",
  journal      = lmag,
  year         = 2006,
  volume       = 7,
  number       = 12,
  pages        = "14--19",
  month        = dec,
  keywords     = "shells, syntax highlighting, tab completion, shell
    programming",
  abstract     = {The Friendly Interactive Shell, or fish, is “friendly”
    because it’s easier to use, not because it’s “dumbed down.”},
  location     = "http://www.jpeek.com/articles/linuxmag/2005-12/"
}

@Article{latb,
  author       = "Sreekishnan Venkateswaran",
  title        = "Linux and the {BIOS}",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 12,
  pages        = "26--30",
  month        = dec,
  keywords     = "assembly code, real mode, bios calls, system management,
    protected mode",
  abstract     = "The x86 kernel has direct and indirect dependencies on the
    system BIOS.  Here’s a look at some of the guts.",
  location     = "http://www.linux-mag.com/id/2357/"
}

@Article{mwfwu,
  author       = "Joab Jackson",
  title        = "Make Way for Wireless {USB}",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 12,
  pages        = "50--52",
  month        = dec,
  keywords     = "usb, wireless devices, ultra wideband",
  abstract     = "USB did away with specialized cables and magic incantations
    to attach peripherals to computers.  Now, Wireless USB plans on doing away
    with cables completely.  Here’s a look at how it works and when you can
    expect it to show up in Linux.", 
  location     = "http://www.linux-mag.com/id/2355/"
}

@Article{ctrws,
  author       = "Roderick~W. Smith",
  title        = "Controlling Time",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 12,
  pages        = "56--58",
  month        = dec,
  keywords     = "ntp, ntp servers, network configuration",
  abstract     = "Keep time synchronized with the Network Time Protocol.",
  location     = "http://www.linux-mag.com/id/2359/"
}

@Article{bujg,
  author       = "Jeremy Garcia",
  title        = "Becoming Unplugged",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 8,
  pages        = 14,
  month        = aug,
  keywords     = "ifplugd, network management",
  abstract     = "Learn how to install and setup ifplugd, a utility that
    configures and reconfigures your network as an Ethernet cable is connected
    and disconnected.",
  location     = "http://www.linux-mag.com/id/2169/"
}

@Article{wsgp3,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part Three",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 8,
  pages        = "16--18",
  month        = aug,
  keywords     = "backups, cp",
  abstract     = "Utility programs like cp have new features you may not have
    seen. Here’s our third of a series about some of the handiest.",
  location     = "http://www.jpeek.com/articles/linuxmag/2005-08/"
}

@Article{patsv,
  author       = "Sreekishnan Venkateswaran",
  title        = "Profiling and Tracing",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 8,
  pages        = "28--32",
  month        = aug,
  keywords     = "kernel profiling, oprofile, trace toolkit",
  abstract     = "Profiling helps find code bottlenecks.  Trace tools provide
    the ability to extract and interpret details about code execution.",
  location     = "http://www.linux-mag.com/id/2151/"
}

@Article{ttnfs,
  author       = "Mark~F. Komarinski",
  title        = "Tuning the {N}etwork {F}ile {S}ystem",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 8,
  pages        = "34--39",
  month        = aug,
  keywords     = "performance tuning, nfs",
  abstract     = "The Network File System is still commonly used to connect
    desktops to file shares and to interconnect compute nodes in
    high-performance clusters.  By tuning NFS — using just a handful of
    parameters and measurements — you can help clients and servers run at peak
    performance.  Here’s how.", 
  location     = "http://www.linux-mag.com/id/2149/"
}

@Article{gwisw,
  author       = "Sam Williams",
  title        = "Git with It!",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 8,
  pages        = "40--43",
  month        = aug,
  keywords     = "distributed source management",
  abstract     = "Just weeks ago, the kernel development team received a clear
    edict from its benevolent dictator Linus Torvalds: Stop using BitKeeper,
    start using (Torvalds's own) Git.  Some foretold of calamity, but what
    impact has Git really had on kernel development? Here's an assessment from
    Torvalds and others.", 
  location     = "http://www.linux-mag.com/id/2089/"
}

@Article{cppt,
  author       = "Roderick~W. Smith",
  title        = "Configuring {PAM}, Part Two",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 8,
  pages        = "58--62",
  month        = aug,
  keywords     = "pam configurations, modules, network authentication, password
    stacks",
  abstract     = "Configuring PAM can be tricky.  Look at some examples and
    learn what rationales work for customizing your own.",
  location     = "http://www.linux-mag.com/id/2153/"
}

@Article{hahtwdsfteioatf,
  author       = "Geroge Varghese and Tony Lauck",
  title        = "Hashed and hierarchical timing wheels: data structures for the efficient implementation of a timer facility",
  journal      = osr # "(" # pot # "Eleventh " # sosp # ")",
  year         = 1987,
  volume       = 21,
  number       = 5,
  pages        = "25--38",
  month        = nov,
  keywords     = "timer queues, timer management, performance, discrete event
    simulations, hashing", 
  abstract     = "Conventional algorithms to implement an Operating System
    timer module take O(n) time to start or maintain a timer, where n is
    the number of outstanding timers: this is expensive for large n.  This
    paper begins by exploring the relationship between timer algorithms, time
    flow mechanisms used in discrete event simulations, and sorting techniques.
    Next a timer algorithm for small timer intervals is presented that is
    similar to the timing wheel technique used in logic simulators.  By using a
    circular buffer or timing wheel, it takes O(1) time to start, stop, and
    maintain timers within the range of the wheel.Two extensions for larger
    values of the interval are described.  In the first, the timer interval is
    hashed into a slot on the timing wheel.  In the second, a hierarchy of
    timing wheels with different granularities is used to span a greater range
    of intervals.  The performance of these two schemes and various
    implementation trade-offs are discussed.", 
  location     = "https://doi.org/10.1145/37499.37504", 
  location     = "http://www.cs.columbia.edu/~nahum/w6998/papers/sosp87-timing-wheels.pdf"
}

@Article{dstjg,
  author       = "Jeremy Garcia",
  title        = "Downloading Source Trees",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 10,
  pages        = "14",
  month        = oct,
  keywords     = "cvs, svn",
  abstract     = "Discover how to check out the latest development tree of your
    favorite projects using CVS or Subversion.",
  location     = "http://www.linux-mag.com/id/2218/"
}

@Article{minis,
  author       = "Michael Bordash",
  title        = "Moodle is Now in Session",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 10,
  pages        = "24--27",
  month        = oct,
  keywords     = "class management systems, web services",
  abstract     = "Teach your staff and students new tricks with the best online
    course management system on the planet.",
  location     = "http://www.linux-mag.com/id/2155/"
}

@Article{tpotsv,
  author       = "Sreekishnan Venkateswaran",
  title        = "The Passage of Time",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 10,
  pages        = "28--34",
  month        = oct,
  keywords     = "jiffies, delay, precision, timer management, real-time
    clock",
  abstract     = "The kernel keeps track of the flow of time.  It PROVIDES
    services to sleep wait for long periods and busy wait for short periods,
    can schedule events to run at a future time, and can do periodic work with
    microsecond precision.  Here’s a look at kernel time.", 
  location     = "http://www.linux-mag.com/id/2272/"
}

@Article{xguaw,
  author       = "Andrew Warfield and Kier Fraser",
  title        = "Xen Grows Up",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 10,
  pages        = "36--41",
  month        = oct,
  keywords     = "paravirtualization, device drivers, operating systems",
  abstract     = "",
  location     = ""
}

@Article{hpurws,
  author       = "Roderick~W. Smith",
  title        = "Hot Plugging {USB}",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 10,
  pages        = "58--61",
  month        = oct,
  keywords     = "usb drivers, usb filesystem, libusb",
  abstract     = "Learn how to get the most out of USB hardware in Linux.",
  location     = "http://www.linux-mag.com/id/2223/"
}

@Article{vcacfsas,
  author       = "Robert~C. Seacord",
  title        = "Validating {C} and " # cpp # " For Safety and Security",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "6--10",
  month        = feb,
  keywords     = "source-code audits, code analysis, security",
  abstract     = "Sometimes the only way to track down security flaws such as 
    buffer overflows is to roll up your sleeves and manually review the code.
    Robert outlines a process for manual review that's based on Safe-Secure
    C/C++.", 
  location     = "http://www.drdobbs.com/validating-c-and-c-for-safety-and-securi/184402075"
}

@Article{skaugas,
  author       = "Glen Matthews",
  title        = "{SSH} {K}erberos Authentication Using {GSSAPI} and {SSPI}",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "11--16",
  month        = feb,
  keywords     = "ssh, kerberos authentication, security contexts",
  abstract     = "Kerberos authentication can be an effective safeguard against
    man-in-the-middle attacks.  Glen implements Kerberos by way of two popular
    APIs.", 
  location     = "http://www.drdobbs.com/ssh-kerberos-authentication-using-gssapi/184402071"
}

@Article{afbmppfc,
  author       = "Robert Kiesling",
  title        = "{A} Frame-Based Message-Passing Parser for {C}",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "18--24",
  month        = feb,
  keywords     = "lexical analysis, stack frames, interpreting c, subexpression
    analysis, ",
  abstract     = "Ctalk, an object-oriented preprocessor for ANSI C, contains a
    novel parser design that's well suited to interpreting object-oriented
    languages.",
  location     = "http://www.drdobbs.com/a-frame-based-message-passing-parser-for/184402070"
}

@Article{saroo,
  author       = "Sander Stoks",
  title        = "Syntactic {A}spartame:  Recreational Operator Overloading",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "25--27",
  month        = feb,
  keywords     = "operator overloading"
}

@Article{acic,
  author       = "Phillip Bruce",
  title        = "Associative Chains in " # cpp,
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "28--33",
  month        = feb,
  keywords     = "pointer-to-member, associative chains, clanks, tangential
    reference",
  abstract     = "Phillip gets around some of the limitations of the
    pointer-to-member with a model of class associations that he calls
    Associative Chains.",
  location     = "http://www.drdobbs.com/associative-chains-in-c/184402067"
}

@Article{micu,
  author       = "Jack Reeves",
  title        = "Multiple Inheritance Considered Useful",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "34--40",
  month        = feb,
  keywords     = "vtables, class layout",
  abstract     = "Arguments against multiple inheritance range from the
    philosophical to the practical, but in the end only one question matters:
    Is it useful?",
  location     = "http://www.drdobbs.com/multiple-inheritance-considered-useful/184402074"
}

@Article{ccsrj,
  author       = "Rex Jaeschke",
  title        = cpp # "\slash {CLI} Sockets",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "41--44",
  month        = feb,
  keywords     = "server-side sockets, client-side sockets, serialization",
  abstract     = "If you want interprocess or interapplication communication,
    you want to know how to use sockets.",
  location     = "http://www.drdobbs.com/ccli-sockets/184402069"
}

@Article{mwek,
  author       = "Andrei Alexandrescu",
  title        = "Maps with Expensive Keys",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "46--49",
  month        = feb,
  keywords     = "maps, keys"
}

@Article{iaait,
  author       = "Andrew Koenig and Barbara~E. Moo",
  title        = "Invariants as an Intellectual Tool",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "50--54",
  month        = feb,
  keywords     = "invariants, program understanding, program design, linear
    search, class invariants", 
  abstract     = "Invariants are a great way to make sure your loops are doing
    what you expect.", 
  location     = "http://www.drdobbs.com/invariants-as-an-intellectual-tool/184402072"
}

@Article{satp3,
  author       = "Pete Becker",
  title        = "{STL} and {TR1}: Part {III}",
  journal      = ccppuj,
  year         = 2006,
  volume       = 24,
  number       = 2,
  pages        = "55--59",
  month        = feb,
  keywords     = "hash tables",
  abstract     = "With TR1, C++ gets hash tables in the form of the template
    classes unordered_map, unordered_multimap, unordered_set, and
    unordered_multiset.",
  location     = "http://www.drdobbs.com/stl-and-tr1-part-iii/184402066"
}

@Article{hips,
  author       = "Scott Granneman",
  title        = "Hide in Plain Sight",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "10",
  month        = jul,
  keywords     = "steganography, image processing",
  abstract     = "Hide messages in images with simple steganography tools.",
  location     = "http://www.linux-mag.com/id/2097/"
}

@Article{tuwht,
  author       = "Jeremy Garcia",
  title        = "Tidy Up With {HTML} {\tt tidy}",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "12",
  month        = jul,
  keywords     = "text processing, pretty printers, html",
  abstract     = "HTML Tidy cleans and pretty prints your HTML.",
  location     = "http://www.linux-mag.com/id/2124/"
}

@Article{wsgp2,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part Two",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "14--18",
  month        = jul,
  keywords     = "grep, color text, non-text search",
  abstract     = "Utility programs like grep have new features that you may not
    have seen.  Here’s the second of a series of articles about some of the
    handiest.",
  location     = "http://www.jpeek.com/articles/linuxmag/2005-07/"
}

@Article{kakb,
  author       = "Michael Bordash",
  title        = "Keeping a Knowledge Base",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "22--24",
  month        = jul,
  keywords     = "knowledge tree, ",
  abstract     = "Work smarter by storing your vital brain tools in an 
    open-source knowledge base.",
  location     = "http://www.linux-mag.com/id/2107/"
}

@Article{kdsvlm,
  author       = "Sreekishnan Venkateswaran",
  title        = "Kernel Debuggers",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "26--28, 60",
  month        = jul,
  keywords     = "debugging, kdb, kgdb, jtag, ",
  abstract     = "Debuggers make kernel internals more transparent.  On Linux,
    they come in different flavors: The Kernel debugger, kdb, the Kernel GNU
    debugger, kgdb, the GNU debugger, gdb, and JTAG- based debuggers.  Learn
    how to use the former three in this month’s column.",
  location     = "http://www.linux-mag.com/id/2103/"
}

@Article{rmrjgc,
  author       = "John Graham-Cumming",
  title        = "Recursive {\tt make} Reloaded",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "30--35",
  month        = jul,
  keywords     = "recursion, make",
  abstract     = "It’s been eight years since recursive make was called
    harmful, but developers still use it.  Here’s how to break the habit.",
  location     = "http://www.linux-mag.com/id/2101/"
}

@Article{isook,
  author       = "Oliver Kiddle",
  title        = "In Search of\ldots",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "36--40",
  month        = jul,
  keywords     = "extended attributes, zsh, variable expansion",
  abstract     = "Extended attributes are a fairly new addition to Linux.
    Learn how to manage files more effectively with extended attributes and the
    Z Shell.", 
  location     = "http://www.linux-mag.com/id/2127/"
}

@Article{cppo,
  author       = "Roderick~W. Smith",
  title        = "Configuring {PAM}, Part One",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 7,
  pages        = "52--55",
  month        = jul,
  keywords     = "pam, configuration files, module stacks",
  abstract     = "Start using the Pluggable Authentication Modules(PAM) system
    to manage login authentication.",
  location     = "http://www.linux-mag.com/id/2105/"
}

@Article{hiobwi,
  author       = "Jeremy Garcia",
  title        = "Hunting {I}\slash {O} Bottlenecks with {\tt iostat}",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 5,
  pages        = "20",
  month        = may,
  keywords     = "performance, io",
  abstract     = "The October 2004 “Tech Support” column showed you how to 
    track down performance bottlenecks using vmstat.  This month, let’s take a
    closer look at input/output (I/O) issues that you may have identified using
    vmstat.",
  location     = "http://www.linuxquestions.org/linux/articles/Jeremys_Magazine_Articles/Hunting_I_O_Bottlenecks_with_iostat"
}

@Article{ftjp,
  author       = "Jerry Peek",
  title        = "Filename Trouble",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 5,
  pages        = "22--26",
  month        = may,
  keywords     = "parsing, shell, quoting, variable substitution, symbolic
    links", 
  abstract     = "Spaces in filenames can cause some pesky problems. But there
    are workarounds.", 
  location     = "http://www.jpeek.com/articles/linuxmag/2005-05/"
}

@Article{wpcdd,
  author       = "Sreekishnan Venkateswaran",
  title        = "Writing {PCMCIA}\slash {CF} Device Drivers",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 5,
  pages        = "32--35, 56",
  month        = may,
  keywords     = "device drivers, pcmcia, card services, host controllers, ",
  abstract     = "Technologies like Wi-Fi, GPRS, and miniature storage devices
    are ubiquitous today as PCMCIA or CF cards.  The Linux kernel supports
    PCMCIA devices on a variety of architectures.",
  location     = "http://www.linux-mag.com/id/1981/"
}

@Article{cprws,
  author       = "Roderick~W. Smith",
  title        = "Creating {PDF}s",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 5,
  pages        = "48--51",
  month        = may,
  keywords     = "postscript, pdf, document management, ghostscript",
  abstract     = "Sharing documents such as papers, reports, and specifications
    is made easy with Adobe’s Portable Document Format (PDF).  Here’s a primer
    on how to create PDFs on Linux.",
  location     = "http://www.linux-mag.com/id/1983/"
}

@Article{ktcars,
  author       = "Scott Granneman",
  title        = "{\tt klik}: True Click-and-Run Software",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 6,
  pages        = 12,
  month        = jun,
  keywords     = "software management, package management",
  abstract     = "Install software safely and easily... with just one klik!",
  location     = "http://www.linux-mag.com/id/2034/"
}

@Article{tdjg,
  author       = "Jeremy Garcia",
  title        = "Tunneling Data",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 5,
  pages        = "26--27",
  month        = may,
  keywords     = "tunneling, networking",
  abstract     = "Network tunneling can be helpful and even necessary, but it 
    can also be used to circumvent security policies.  Here’s a survey of the
    best tunneling tools available and a list of techniques that may help you
    detect active tunnels.", 
  location     = "http://www.linux-mag.com/id/2062/"
}

@Article{wsgpo,
  author       = "Jerry Peek",
  title        = "What's {GNU}, Part One",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 6,
  pages        = "30--32",
  month        = jun,
  keywords     = "ls, shell commands",
  abstract     = "Utility programs like ls have new features that you may not
    have seen. This is the first in a series about some of the handiest
    enhancements.",
  location     = "http://www.jpeek.com/articles/linuxmag/2005-06/"
}

@Article{nswpc,
  author       = "Sreekishnan Venkateswaran",
  title        = "Networking, Storage with {PC} Cards",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 6,
  pages        = "38--41",
  month        = jun,
  keywords     = "pcmcia storage, cardbus, 802 wlan cards"
}

@Article{taoep,
  author       = "Sam Hopkins",
  title        = "The {ATA} over {E}thernet Protocol",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 6,
  pages        = "48--51",
  month        = jun,
  keywords     = "ata, ethernet"
}

@Article{tsotpt,
  author       = "Sam Williams",
  title        = "The State of the Penguin: Telecom",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 6,
  pages        = "54--57",
  month        = jun,
  keywords     = "cost, unix",
  abstract     = "From data centers to hand held receivers, Linux is changing
    how manufacturers and carriers do business — for the better.",
  location     = "http://www.linux-mag.com/id/2030/"
}

@Article{tuptpt,
  author       = "Jerry Peek",
  title        = "The Unknown Power Tool, Part Two",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "20--22, 62",
  month        = mar,
  keywords     = "included files, diversions, m4, macro processors",
  abstract     = "Dig deeper into m4, and look at included files, diversions,
    frozen files, and debugging and tracing.",
  location     = "http://www.linux-mag.com/id/1903/"
}

@Article{syep2,
  author       = "Michael Bordash",
  title        = "Securing Your Environment, Part 2",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "24--26",
  month        = mar,
  keywords     = "snort, acid, intrusion detection, security",
  abstract     = "SNORT looks for intrusions, while ACID can help you make
    sense of what’s happened after an intrusion.",
  location     = "http://www.linux-mag.com/id/1895/"
}

@Article{wakld,
  author       = "Sreekishnan Venkateswaran",
  title        = "Writing a Kernel Line Discipline",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "28--32",
  month        = mar,
  keywords     = "line disciplines, i-o processing, operating systems",
  abstract     = "Look at the internals of a line discipline and implement a 
    simple line discipline for a serial touch screen controller.",
  location     = "http://www.linux-mag.com/id/1891/"
}

@Article{tlerws,
  author       = "Roderick~W. Smith",
  title        = "The {L}inux {ER}",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "34--38",
  month        = mar,
  keywords     = "system recovery, recovery disks, file systems, system
    management, hardware failures", 
  abstract     = "A variety of causes — a forgotten root password, corrupted
     partition tables, or a corrupt filesystem — can lead to serious problems,
     up to and including an inability to boot the computer.  When such problems
     occur, it’s time to reach for your first aid kit.  Not prepared? Scrub in
     and learn how to handle the worst.  Welcome to the Linux ER.", 
  location     = "http://www.linux-mag.com/id/2242/"
}

@Article{twkmr,
  author       = "Mark Ramm",
  title        = "The Watcher Knows",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "40--44",
  month        = mar,
  keywords     = "zabbix servers, system management, monitoring",
  abstract     = "It’s 3 a.m.  Do you know what your servers are doing? Is your
    web server struggling to handle its load? Is one of your application
    servers running out of hard disk space or memory? Is that legacy Windows
    server infected with the worm of the week? ZABBIX knows.", 
  location     = "http://www.linux-mag.com/id/1890/"
}

@Article{tcst,
  author       = "Matt Frye",
  title        = "The Coroner's Toolkit",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "46--49, 62",
  month        = mar,
  keywords     = "file system recovery, system management",
  abstract     = "When a malcontent breaks into, or cracks, your computer, your
    reactions are likely to be very much the same.  What was taken? What was
    left behind? Is the computer safe to use? How can I keep my computer safer
    in the future? To find answers, reach for The Coroner’s Toolkit.", 
  location     = "http://www.linux-mag.com/id/1889/"
}

@Article{tdus,
  author       = "Roderick~W. Smith",
  title        = "Tracking Down Unnecessary Servers",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 3,
  pages        = "50--52",
  month        = mar,
  keywords     = "netstat, system management, security",
  abstract     = "To keep your system running securely and efficiently, you 
    should periodically audit your system, looking for servers that need not be
    running.  Here’s how to do it.", 
  location     = "http://www.linux-mag.com/id/1893/"
}

@Article{fafc,
  author       = "Jeremy garcia",
  title        = "Faster and Faster Compilation",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 4,
  pages        = "18",
  month        = apr,
  keywords     = "distcc, ccache, optimizations, compilation",
  abstract     = "Learn how to use ccache and distcc to speed up compilation.",
  location     = "http://www.linux-mag.com/id/1940/"
}

@Article{mdsjp,
  author       = "Jerry Peek",
  title        = "More Data Surgery",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 4,
  pages        = "20--24",
  month        = apr,
  keywords     = "fmt, argument groups, join, text processing, column, printf",
  abstract     = "Got text data? Linux has a variety of tools to format,
    process, and print it.", 
  location     = "http://www.linux-mag.com/id/1921/"
}

@Article{wtw,
  author       = "Steve Friedl",
  title        = "Watching the {W}eb",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 4,
  pages        = "30--34, 56",
  month        = apr,
  keywords     = "referrers, traffic analysis, statistics",
  abstract     = {Everyone that runs a web site wants to know “How am I doing?”
    The total number of hits, the number of unique visitors, and what pages are
    the most popular are just a few of the metrics that gauge a site’s traffic.
    All of that important data exists in the web server’s log — if only you can
    tease it out.  While several commercial applications provide such analysis,
    The Webalizer is a free and fast log analyzer that may just be superior,
    too.  Here’s a hands-on guide.}, 
  location     = "http://www.linux-mag.com/id/1942/"
}

@Article{tpws,
  author       = "Jeremy Garcia",
  title        = "Transparent Proxying with {S}quid",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 4,
  pages        = "36--38, 58",
  abstract     = "caching, squid, proxying",
  month        = apr,
  keywords     = "Squid is often used as a reverse proxy to spare web servers
    from repeated requests for the same content.  But Squid can also be used to
    spare you from interminable delays when requesting content.  Deployed as a
    local caching proxy, Squid can reduce your site’s bandwidth consumption and
    make browsing more responsive.  Learn how it works, and start saving time
    and money today.", 
  location     = "http://www.linux-mag.com/id/1928/"
}

@Article{pbrws,
  author       = "Roderick~W. Smith",
  title        = "Partimage Backups",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 4,
  pages        = "46--48",
  month        = apr,
  keywords     = "disk imaging, disk back-ups, file systems",
  abstract     = "Whatever you’re doing, stop! Have you backed up your systems
    today? If so, great! If not, try Partimage to make copies of entire
    partitions.", 
  location     = "http://www.linux-mag.com/id/1929/"
}

@Article{rclts,
  author       = "Scott Granneman",
  title        = "Rip, Convert, Listen: The Sequel",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "16",
  month        = dec,
  keywords     = "audio",
  abstract     = "If you listen to Ogg Vorbis files, KRename and EasyTAG makes
    organizing those files a snap.", 
  location     = "http://www.linux-mag.com/id/2070/"
}

@Article{qtadb,
  author       = "Jeremy Garcia",
  title        = "Quick Tricks and Dirty Backups",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "18",
  month        = dec,
  keywords     = "backups, rsync",
  abstract     = "Let's face it, even rsync and tar is better than nothing.",
  location     = "http://www.linux-mag.com/id/1816/"
}

@Article{ottraoof,
  author       = "Jerry Peek",
  title        = "On the {T}(r)ail of Open Files",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "20--22",
  month        = dec,
  keywords     = "open files, file systems, ",
  abstract     = "Learn how Linux manages open files and explore a number of
    utilities to watch files as they grow.",
  location     = "http://www.jpeek.com/articles/linuxmag/2004-12/"
}

@Article{smmb,
  author       = "Michael Bordash",
  title        = "Streaming {MP3}s",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "26--28",
  month        = dec,
  keywords     = "zina, music server, mp3",
  location     = "http://www.linux-mag.com/id/1819/"
}

@Article{silrws,
  author       = "Roderick~W. Smith",
  title        = "Sound in {L}inux",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "34--41",
  month        = dec,
  keywords     = "sound managers, sound drivers, alsa, oss, sound libraries"
}

@Article{pmgnmf,
  author       = "Nigel McFarlane",
  title        = "Power {M}ozilla {GUI}s",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "42--49",
  month        = dec,
  keywords     = "xul, platform guis, interface building",
  location     = "http://www.linux-mag.com/cgi-bin/r?m=r60&u=60/mozilla_01.html"
}

@Article{tfwf,
  author       = "Roderick~W. Smith",
  title        = "Tweaking Fonts with {FontForge}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 12,
  pages        = "58--59, 71",
  month        = dec,
  keywords     = "fonts, characters",
  location     = "http://www.linux-mag.com/id/1820/"
}

@Article{mmmpo,
  author       = "Jerry Peek",
  title        = "Magnificent Macro Magic, Part One",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 2,
  pages        = "16--19, 71",
  month        = feb,
  keywords     = "m4, macro processing, text processing, quoting, ",
  abstract     = "m4 is a powerful macro processor that's been around for more
    than thirty years.  Here's the first of two parts, introducing its many
    magnificent talents.",
  location     = "http://www.linux-mag.com/id/163/"
}

@Article{tapr,
  author       = "Ryan Bloom",
  title        = "The {A}pache {P}ortable {R}untime",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 2,
  pages        = "32--36",
  month        = feb,
  keywords     = "system portability, portability layer",
  abstract     = "If you’ve ever had to write a portable application in C,
    you’ve likely run into the same problem faced by countless other
    programmers: no matter how much you try to stick to a well-defined
    application programming interface (API), the program just doesn’t work the
    same on every platform.  While POSIX does a passable job of providing a
    portable API for most Unix and Unix-like platforms, POSIX either doesn’t
    exist on other operating systems or is so full of bugs as to be unusable.
    Moreover, POSIX isn’t always the best choice.  Non-Unix platforms, such as
    Microsoft Windows, have their own APIs that are better mantained and
    perform better on that platform.  So, to make something portable, you could
    write, rewrite, and tweak your code several times — at least so the code
    compiles on several platforms.  Or, you can use the Apache Portable Runtime
    (http://apr.apache.org/) the same library that makes the ubiquitous Apache
    HTTP server portable.  If it’s good enough for Apache, well, enough said.", 
  location     = "http://www.linux-mag.com/id/154/"
}

@Article{totitb,
  author       = "Jon Erickson",
  title        = "The Oldest Trick in the Book",
  journal      = lmag,
  year         = 2005,
  volume       = 7,
  number       = 2,
  pages        = "38--46",
  month        = feb,
  keywords     = "security, secure programming, hacking, buffer overflow, shell
    code, exploits",
  abstract     = "Learn about buffer overflow exploits and how to avoid them.",
  location     = "http://www.linux-mag.com/id/155/"
}

@Article{kfss,
  author       = "Janson Perlow",
  title        = "Keeping {F}edora Ship-Shape",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "18--20",
  month        = oct,
  keywords     = "system management, fedora",
  abstract     = "I've started to have a sort of love-hate relationship with
    Fedora.  On the one hand, I like the fact that the Fedora Project keeps
    their distribution constantly up-to-date, making all of the latest and
    greatest advancements in KDE, GNOME, OpenOffice.org, and so on available to
    me.  On the other hand, Fedora can sometimes be as stable as Anne Heche
    strung out on peyote.", 
  location     = "http://www.linux-mag.com/id/1772/"
}

@Article{pial,
  author       = "Jeremy Garcia",
  title        = "Peeking In, At {L}inux",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "24",
  month        = oct,
  keywords     = "font management, true type fonts",
  location     = "http://www.linuxquestions.org/linux/articles/Jeremys_Magazine_Articles/Peeking_In_At_Linux"
}

@Article{pdsjp,
  author       = "Jerry Peek",
  title        = "Performing Data Surgery",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "26--28",
  month        = oct,
  keywords     = "data management, dd, ",
  abstract     = "A year ago, the November 2003 Power Tools column (available
    online at http://www.linux-mag.com/2003-11/power_01.html) looked into some
    lesser-known tools for editing text: the line editors ex and ed, and the
    stream editor sed.",
  location     = "http://www.linux-mag.com/id/1775/"
}

@Article{egcca,
  author       = "Clay Andres",
  title        = "Enterprise Grid Computing",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "38--42",
  month        = oct,
  keywords     = "grid computing, enterprise computing",
  abstract     = "Imagine all of the processing power within your enterprise -
    from every large and small server and cluster in every datacenter, to every
    networked personal computer - all available to work on solving the day's
    business problems.  That's the notion of an enterprise grid, and if the
    Enterprise Grid Alliance (EGA) fulfills its mission, a company-wide
    computing farm will be a reality.", 
  location     = "http://www.linux-mag.com/id/1768/"
}

@Article{naxaw,
  author       = "Andrew Warfield and Keir Fraser",
  title        = "Now and {X}en",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "44--50",
  month        = oct,
  keywords     = "paravirtualization, virtual machines",
  abstract     = "How would you like to run several operating systems at once
    on the same physical hardware with virtually no performance overhead - and
    for free? That's the promise and the purpose of Xen, a relatively new open
    source project that turns one piece of hardware into many, virtually.  If
    you're looking to cut costs or maximize usage or both, follow the path to
    Xen.", 
  location     = "http://www.linux-mag.com/id/1769/"
}

@Article{uaorbs,
  author       = "Roderick~W. Smith",
  title        = "Using {A}pt on {RPM}-Based Systems",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "56--58",
  month        = oct,
  keywords     = "package management, software managment",
  abstract     = "Managing packages can be a tricky undertaking, even with
    package tools like the RPM Package Manager (RPM), the package management
    tool used by Conectiva, Fedora, Mandrake, Red Hat, SuSE, Yellow Dog, and
    many other distributions.  With RPM, you may try to install a package, only
    to find that it depends on others you don't have.  Or, you might discover
    that your packages are several versions out of date and then have to track
    down and install potentially dozens of updates to fix security and other
    problems with the old packages.", 
  location     = "http://www.linux-mag.com/id/1779/"
}

@Article{pwj,
  author       = "Jason Perlow",
  title        = "{P2P} with {J}ava",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 11,
  pages        = "18--20",
  month        = nov,
  keywords     = "p2p networking, java, bittorrent",
  abstract     = "In this installment, I'd like to touch on an oft-forgotten
    but increasingly important component of the Linux desktop: Java
    applications.  Since Java is largely distribution neutral, what Java code
    works on Fedora Core works for Debian, Red Hat, SuSE, Mandrake, and any
    number of other distributions.  And, yes, Java applications really do
    exist, and some are actually good.", 
  OPTlocation  = "http://www.linux-mag.com/id/1795/"
}

@Article{rclsg,
  author       = "Scott Granneman",
  title        = "Rip Convert Listen",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 10,
  pages        = "22",
  month        = nov,
  keywords     = "music files, ripping, conversion",
  abstract     = "Linux offers several excellent music players, including (but
    not limited to) XMMS, Zinf, noatun, amaroK, Juk, Rhythmbox, and Kaffeine.
    Most of these can play streaming Internet audio, compact discs, and best of
    all, digital audio files.  With music stored as digital audio files, you
    can enjoy your music wherever and whenever you want to.", 
  location     = "http://www.linux-mag.com/id/1796/"
}

@Article{apalm,
  author       = "Jeremy garcia",
  title        = "Alien Packages and {L}inux Mirrors",
  journal      = lmag,
  year         = 2005,
  volume       = 6,
  number       = 11,
  pages        = "24",
  month        = nov,
  keywords     = "package management, rpms"
}

@Article{gam,
  author       = "Jerry Peek",
  title        = "{gFTP} and More",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 11,
  pages        = "26--29",
  month        = nov,
  keywords     = "ftp, file transfer, protocols, ",
  abstract     = "Linux often gives you lots of ways to do the same thing and
    file transfer is no exception.  We covered file transfer in three columns
    from March to May 2003 (available online at
    http://www.linux-mag.com/depts/power.html).  This month let's look at yet
    another variation using gFTP and some not-so-obvious details that can help
    you navigate all of the file transfer protocols.", 
  location     = "http://www.linux-mag.com/id/1798/"
}

@Article{aclrws,
  author       = "Roderick~W. Smith",
  title        = "Access Control Lists",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 11,
  pages        = "64--66",
  month        = nov,
  keywords     = "acl, file systems, file permissions",
  abstract     = "If you've used Linux for a long time, you're probably quite
    familiar with file permissions.  Indeed, managing permissions is a critical
    part of managing a Linux system.", 
  location     = "http://www.linux-mag.com/id/1802/"
}

@Article{utceg,
  author       = "Eric Gufford",
  title        = "Unit Testing \& {CxxTest}",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "6--10",
  month        = dec,
  keywords     = "unit testing, logging, test fixtures",
  abstract     = "Unit testing can save you time and catch bugs early in the
    development cycle, but it can be tedious to set up.  CxxTest is a framework
    that uses Perl to automate the creation of test classes for your
    application.", 
  location     = "http://www.drdobbs.com/unit-testing-cxxtest/184402043"
}

@Article{ctad,
  author       = "Klaus Wittlich",
  title        = "Compile-Time Assertions \& Debugging",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "11--12",
  month        = dec,
  keywords     = "compile-time assertions, debugging",
  abstract     = "It's common practice to use assertions to check invariants at
    runtime, but assertions can be equally useful at compile time for doing
    things like checking arrays for proper size and order.", 
  location     = "http://www.drdobbs.com/compile-time-assertions-debugging/184402051"
}

@Article{afffer,
  author       = "Terence Parker",
  title        = "{A} Flexible Framework For Error Reporting",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "14--18",
  month        = dec,
  keywords     = "singletons, logging",
  abstract     = "Errors can often occur deep in a class or subroutine, but the
    way you present that error should ideally be dependent on context.  The
    solution is to separate error generation from error reporting.", 
  location     = "http://www.drdobbs.com/a-flexible-framework-for-error-reporting/184402048"
}

@Article{mlpel,
  author       = "Giri Mandalika",
  title        = "Mixed-Language Programming \& Extended Linkage",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "20--22",
  month        = dec,
  keywords     = "external linkage, c++, name mangling",
  abstract     = "Calling C code from C++ should be relatively straightforward,
    but understanding the concept of linkage is key to ensuring a smooth
    compile.",
  location     = "http://www.drdobbs.com/mixed-language-programming-external-lin/184402045"
} 

@Manual{tsotje,
  title        = "The {\sc Opal} Tutorial",
  author       = "J{\" u}rgen Exner",
  organization = "The {\sc Opal} Group, Technische Universit{\" a}t Berlin",
  year         = 1994,
  month        = "16 " # feb,
  keywords     = "functional programming",
  abstract     = "This tutorial describes the functional programming language
    Opal which was developed by the Opal Group at the Technische Universitat
    Berlin.  It explains how to use Opal from an intuitive approach.  No prior
    knowledge of functional programming will be assumed.  Although this
    tutorial explains Opal in depth, it does not define the language.  In cases
    of ambiguity, you should consult the reference manual The Programming
    Language Opal",
  location     = "http://projects.uebb.tu-berlin.de/opal/trac/raw-attachment/wiki/Documentation/tutorial.pdf"
}

@Article{aiitact,
  author       = "Matthew Wilson",
  title        = "Adapting Interface-Incomplete Types At Compile Time",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "21--28",
  month        = dec,
  keywords     = "interface incomplete types, immutable collections, inferred
    interface adaptation, type selection, type detection, type fixing, sfinae",
  abstract     = "When an adapter template makes demands that a potential under
    lying type cannot fulfill, Interred Interface Adaptation can expand the
    number of adaptable types.",
  location     = "http://www.drdobbs.com/adapting-interface-incomplete-types-at-c/184402050"
}

@Article{hsmdic,
  author       = "Dmitry Babitsky",
  title        = "Hierarchical State Machine Design in " # cpp,
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "30--35",
  month        = dec,
  keywords     = "statecharts, finite state machines, ",
  abstract     = "In a Hierarchical Finite State Machine, any state can be a 
    substate of some larger state.  Dmitry presents a class that implements
    this pattern.",
  location     = "http://www.drdobbs.com/hierarchical-state-machine-design-in-c/184402040"
}

@Article{gacnpmt,
  author       = "Nikos Platis and Mihalis Tsoukalos",
  title        = "GraphViz and " # cpp,
  journal      = ccpuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "38--42",
  month        = dec,
  keywords     = "graphviz, visualizations, graphs",
  abstract     = "The Boost Graph Library (BGL) is a great way to use GraphViz
    to draw directed and undirected graphs of your data structures.",
  location     = "http://www.drdobbs.com/cpp/graphviz-and-c/184402049"
}

@Article{ccio,
  author       = "Rex Jaeschke",
  title        = cpp # "\slash{CLI} Input\slash Output",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "44--49",
  month        = dec,
  keywords     = "i/o classes, file i/o, string i/o, type unformatted i/o,
    random access i/o, directory operations, ",
  abstract     = "Rex covers the ABCs of reading and writing in the .NET/CLI
    realm, including screen and keyboard I/O, file and string I/O, and
    operations on files and directories.", 
  location     = "http://www.drdobbs.com/ccli-inputoutput/184402044"
}

@Article{pbma,
  author       = "Andrei Alexandrescu and Emery Berger",
  title        = "Policy-Based Memory Allocation",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "50--54",
  month        = dec,
  keywords     = "mailcontainer, memory allocation, heap, resizing, ",
  abstract     = "The way your application allocates memory can have a dramatic
    effect on its performance.  Modern general-purpose memory allocators are
    pretty efficient, but there's always room for improvement.", 
  location     = "http://www.drdobbs.com/policy-based-memory-allocation/184402039"
}

@Article{tpova,
  author       = "Andrew Koenig and Barbara~E. Moo",
  title        = "The Perils of Violating Abstractions",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "55--57",
  month        = dec,
  keywords     = "abstractions, concrete data structures, ",
  abstract     = "Some programming abstractions seem like they can safely be 
    violated.  There are reasons, however, why you should think twice before
    doing so--a little self-discipline can have big payoffs.", 
  location     = "http://www.drdobbs.com/the-perils-of-violating-abstractions/184402046"
}

@Article{satp1,
  author       = "Pete Becker",
  title        = "{STL} and {TR1}: Part {I}",
  journal      = ccppuj,
  year         = 2005,
  volume       = 23,
  number       = 12,
  pages        = "58--61",
  month        = dec,
  keywords     = "sequences, iterators, function objects, containers",
  abstract     = "The TR1 implementation of the Standard Template Library
    contains new data collections and callable types.  To understand these,
    it's important to grasp some fundamentals of the design of the STL.", 
  location     = "http://www.drdobbs.com/stl-and-tr1-part-i/184402041"
}

@Article{tljp,
  author       = "Jerry Peek",
  title        = "Think Links",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 9,
  pages        = "26--28, 63",
  month        = sep,
  keywords     = "links, command-line, file systems",
  abstract     = "Why would you want to give a program more than one name? How
    can you move quickly through the filesystem like Star Trek's Enterprise
    jumping through a worm hole? What good are multiple views of the files in a
    directory? You'll see these things and more, as we look into Linux
    filesystem links.", 
  location     = "http://www.linux-mag.com/id/1751/"
}

@Article{ccrpt,
  author       = "Roderick~W. Smith",
  title        = "Creating Custom {RPM}s, Part Two",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 9,
  pages        = "50--52",
  month        = sep,
  keywords     = "package management, software management, custom packages",
  abstract     = "Last month's column looked at the basics of generating RPMs,
    including the format of the all-important .spec file.  In theory, those
    principles should be enough to let you create .spec files and RPMs for a
    number of purposes.  In practice, however, RPM generation is complex enough
    that some examples are sure to help.  So, this month's column presents two
    examples: creating a non-program RPM and creating a program RPM.", 
  location     = "http://www.linux-mag.com/id/1754/"
}

@Article{wzirfy,
  author       = "anonymous",
  title        = "Which Zip is Right for You?",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = 8,
  month        = jun,
  keywords     = "compression",
  abstract     = "In the old days, disk space cost a pretty penny, so saving
    space was essential.  But now that disk space costs about $0.50 per
    gigabyte, a lot of folks never worry about deleting files, let alone
    compressing them.  However, if you're administering a large, shared server
    (such as for email), it seems that you can never have too much space.", 
  location     = "http://www.linux-mag.com/id/1679/"
}

@Article{j15jbng,
  author       = "Joshua Bloch and Neal Gafter",
  title        = "Java 1.5",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = "18--25",
  month        = jun,
  keywords     = "java, language design, generics, autoboxing, iterations,
    enums, varargs, static import"
}

@Article{mfj,
  author       = "Cedric Beust",
  title        = "Metadata for {J}ava",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = "26--30",
  month        = jun,
  keywords     = "metadata, annotations, javadoc",
  abstract     = "Metadata is information that cannot be expressed in Java, but
    is nevertheless important for your Java application to work properly.
    Currently, metadata is expressed in separate text, Java properties, and XML
    files, but that poses a serious problem: code is disconnected from
    configuration, making development, deployment, and maintenance that much
    more difficult.  JDK 1.5 addresses this disparity, capturing critical
    information where it belongs: right in your code.", 
  location     = "http://www.linux-mag.com/id/1676/"
}

@Article{akafa,
  author       = "Bull Burke and Marc Fleury",
  title        = "{A} Killer App for {AOP}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = "32--35, 59",
  month        = jun,
  keywords     = "aspects-oriented programming, software development,
    crosscutting concerns, jboss, java, middleware",
  abstract     = "Aspect-oriented programming has been gaining a wider audience
    of late, as enterprise application developers discover that AOP provides
    for more intuitive, extensible, and flexible middleware.  With JBoss AOP,
    provided in JBoss 4, developers can write plain old Java objects (POJOS)
    and request complex services like transactions, security, and caching with
    just a few simple annotations.", 
  location     = "http://www.linux-mag.com/id/1677/"
}

@Article{earjp,
  author       = "Jerry Peek",
  title        = "Execution and Redirection",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = "36--38",
  month        = jun,
  keywords     = "shell commands, redirection, file descriptors",
  abstract     = "While the title of this month’s “Power Tools” is “Execution
    and Redirection,” it’s not about about dying and going to heaven.  Instead,
    controlling execution and redirecting input and output is an important part
    of managing Linux processes.  Let’s dig into these two topics, learn the
    basics, and then see some shell features for managing processes that are
    little-known, but indispensable nonetheless.", 
  location     = "http://www.jpeek.com/articles/linuxmag/2004-06/"
}

@Article{pl26em,
  author       = "Ethan McCallum",
  title        = "Programming {L}inux 2.6",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = "44--46, 63",
  month        = jun,
  keywords     = "asynchronous io, access control lists, extended attributes,
    epoll(), cpu affinity, oprofile, threading, seqlocks, futexes",
  abstract     = "sKernel 2.6 is finally here, and it touts several
    enhancements over the 2.4 series.  The press has highlighted changes
    relevant to systems architects and managers, but there's plenty in 2.6 for
    application developers, too.", 
  location     = "http://www.linux-mag.com/id/1684/"
}

@Article{fifwn,
  author       = "Jerry Peek",
  title        = "Fix Images Fast with {N}etpbm",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 8,
  pages        = "16--21",
  month        = aug,
  keywords     = "image processing, shell programming, netpbm",
  location     = "http://www.linux-mag.com/id/1728/"
}

@Article{elims,
  author       = "Inder~M. Singh",
  title        = "Embedded {L}inux",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 8,
  pages        = "32--37",
  month        = aug,
  keywords     = "real-time, embedded systems, scheduling, pre-emption,
    synchronization, standards"
}

@Article{ktkam,
  author       = "Andrew Morton",
  title        = "Keeping the Kernel",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 6,
  pages        = "38--42",
  month        = aug,
  keywords     = "scaling, patches submission, scheduling"
}

@Article{ccrpo,
  author       = "Roderick~W. Smith",
  title        = "Creating Custom {RPM}s, Part One",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 8,
  pages        = "50--52",
  month        = aug,
  keywords     = "rpms, package management, software management",
  abstract     = "RPMs can be a great way to manage the packages you install on
    your system.  Unfortunately, not everything you might want to install is
    available in RPM form.  Perhaps you need a more recent version of a program
    than the one that ships with your distribution; or maybe it's a program you
    wrote yourself; or perhaps it's just something that's very obscure.
    Similar dilemmas can occur with non-program packages, such as font or clip
    art collections.", 
  location     = "http://www.linux-mag.com/id/1731/"
}

@Article{hntbalp,
  author       = "Jason Perlow",
  title        = "How Not To Build a {L}inux {PDA}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = "12--14",
  month        = may,
  keywords     = "developers, product roll-outs, sdks",
  abstract     = "Last month, I touched a little bit on HP's screwed up Linux
    PDA initiative, but perhaps I was a bit too harsh.  Sure, they have a
    research arm that's completely underutilized and they have absolutely no
    clue as how to turn those efforts into a product, but HP is in no way
    unique in their absence from the PDA and Linux device cluetrain.  For the
    most part, the entire industry needs a swift kick in the head to see how to
    build and market a successful Linux handheld and to learn how to properly
    support open source PDA developers.  I learned how the hard way, and here's
    my painful perspective on the whole shebang.", 
  location     = "http://www.linux-mag.com/id/1654/"
}

@Article{toldb,
  author       = "Dan Burcaw",
  title        = "The Other {L}inux",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = "18--20, 58",
  month        = may,
  keywords     = "powerpc, macs, apple",
  abstract     = "Linux on Intel is driving the commoditization of computing.
    But it's not the only game in town, nor is it the only combination of
    software and hardware with influence.  Linux also runs on PowerPC
    processors - including IBM's POWER series, Apple's G5, and other embeddable
    cores - and runs well.  Here's a look at the other Linux, the one that runs
    on PPC.", 
  location     = "http://www.linux-mag.com/id/1648/"
}

@Article{s1wn,
  author       = "William Nagel",
  title        = "Subversion 101",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = "22--26",
  month        = may,
  keywords     = "revision control, cvs, software tools, software development",
  abstract     = "The new open source version control promises to obsolete
    CVS.",
  location     = "http://www.linux-mag.com/id/1649/"
}

@Article{bnwhw,
  author       = "Howard Wen",
  title        = "Brave New Worlds",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = "28--30, 60--61",
  month        = may,
  keywords     = "virtual worlds, acorn, worldforge, mmorpgs",
  abstract     = "A number of open source projects, including WorldForge and
    NeL, are redefining the frontiers of massively-multiplayer gaming.  Take a
    peek at the games, the gearheads, and the gizmos that make play work", 
  location     = "http://www.linux-mag.com/id/1650/"
}

@Article{gclc,
  author       = "Jerry Peek",
  title        = "Great Command-Line Combinations",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = "32--34",
  month        = may,
  keywords     = "command lines, shell command language, looping",
  abstract     = "Tools with graphical user interfaces (GUIs) can be easy to
    learn.  All of their commands and options are typically laid out on menus
    and dialog boxes, making it easy to discover what the tool can do.  If easy
    and intuitive are your main criteria for programs, then a GUI tool may
    always be the right choice.", 
  location     = "http://www.linux-mag.com/id/1655/"
}

@Article{aflatncd,
  author       = "Roderick~W. Smith",
  title        = "{A} First Look at the New {CIFS} Driver",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = "36--38",
  month        = may,
  keywords     = "smb, cifs, samba",
  abstract     = "Samba is a file and print server that runs under Linux and
     other Unix-like operating systems.  Samba is an implementation of the
     Server Message Block (SMB) protocol, also known as the Common Internet
     File System (CIFS), which is a popular file- and printer-sharing protocol
     on Windows.", 
  location     = "http://www.linux-mag.com/id/1656/"
}

@Article{ulawd,
  author       = "Jeremy Garcia",
  title        = "Using {L}ogwatch and Watching {DVD}s",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 5,
  pages        = 48,
  month        = may,
  keywords     = "logs, media players"
}

@Article{ukws,
  author       = "Jeremy Garcia",
  title        = "Using Keys with {SSH}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 7,
  pages        = 18,
  month        = jul,
  keywords     = "ssh, key management, security"
}

@Article{gefyvnho,
  author       = "Jerry Peek",
  title        = "Great Email Features (You've Never Heard Of)",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 7,
  pages        = "30--34",
  month        = jul,
  keywords     = "plain text, delayed reading, redirection, sharing,
    priorities, scoring, saving, filtering",
  abstract     = "Some of the handiest features of email programs may be the
    ones that you don't realize they have.  Read on to discover what you're
    missing.", 
  location     = "http://www.linux-mag.com/id/1698/"
}

@Article{lotl,
  author       = "Jonathan~A. Zdziarski",
  title        = "Linux on the Laptop",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 7,
  pages        = "36--41",
  month        = jul,
  keywords     = "power management, frequency scaling, disk spin-down, swap
    management, minipci cards, windows drivers, war driving, mobile phone data
    calls",
  abstract     = "Linux is an extremely flexible operating system.  With just a
    little bit of creativity, Linux can be tailored to your laptop, making your
    mobile computer just as useful as your desktop or server.  Try these ten
    tips and keep yourself and Linux on-the-go.", 
  location     = "http://www.linux-mag.com/id/1700/"
}

@Article{lata,
  author       = "Roderick~W. Smith",
  title        = "Linux and the {AMD64}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 7,
  pages        = "42--44, 66--67",
  month        = jul,
  keywords     = "64-bit architectures, performance",
  abstract     = "Linux was created on the first 32-bit CPU in the x86 CPU
    family, the 80386.  But the days of 32-bit computing are coming to an end.
    Luckily, the AMD64 provides compatibility features that ease the
    transition.  Here's a hands-on guide to building and benchmarking a 64-bit
    Linux desktop based on AMD64.", 
  location     = "http://www.linux-mag.com/id/1699/"
}

@Article{strws,
  author       = "Roderick~W. Smith",
  title        = "{SSH} Tunneling",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 7,
  pages        = "50--53",
  month        = jul,
  keywords     = "tunneling, ssh, client configuration, server configuration,
    passwords, x tunneling",
  abstract     = "Security has long been an important computer issue, but it's
    become increasingly relevant as the number and severity of threats has
    risen.",
  location     = "http://www.linux-mag.com/id/1705/"
}

@Article{dimdon,
  author       = "Shoshana Loeb",
  title        = "Delivering Interactive Multimedia Documents Over Networks",
  journal      = ieeecom,
  year         = 1992,
  volume       = 30,
  number       = 5,
  pages        = "52--59",
  month        = may,
  keywords     = "network edge, protocols, application semantics, document
    classes, p-objects, viewing strategies",
  abstract     = "A family of applications that consists of interactive
    multimedia documents, such as electronic magazines and interactive TV
    shows, is examined and the links between application architecture, user
    behavior, and network performance are investigated.  The kinds of
    application-specific information that influence the end-to-end quality of
    service are discussed.  The architecture and dynamics of the interactive
    document in terms of presentation objects (P-Objects), which are the
    segments of information accessed by the application and which are described
    according to their size, media composition, and access links, are
    described.  The same structural characteristics that may make an
    interactive multimedia document appealing to the end user are the
    characteristics that are helpful during dynamic network performance
    optimization.  This observation is based on the hypothesis that the
    P-Objects' access graph, together with viewing time statistics, is the
    information most useful to the network delivery control mechanism for
    optimizing network performance.  Preliminary guidelines for both network
    and application designers to address each other's concerns are presented.",
  location     = "http://dx.doi.org/10.1109/35.137479"
}

@Article{widwmh,
  author       = "Jason Perlow",
  title        = "What {I} Did With My Hiatus",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "12--13",
  month        = mar,
  keywords     = "community service, software, xandros",
  abstract     = "Every time you go on a long trip, it's always great to come
    back home.  That's how it is with my return to Linux Magazine.  After two
    long years, I'm back in the business of writing a column, and I'm as happy
    as a clam.  I'm clearing off my old dusty desk, restocking its drawers with
    Penguin Mints and Instant Ramen, and firing up every piece of computer
    hardware that can run Linux that I can get my hands on.", 
  location     = "http://www.linux-mag.com/id/1605/"
}

@Article{sfmgn,
  author       = "Rex Young and Dominique Cinafranca",
  title        = "Strategies for Managing Growing Networks",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "22--25, 49",
  month        = mar,
  keywords     = "dynamic routing, networking, border gateway protocols",
  abstract     = "Building an extensible enterprise-class network requires the
    right tools and forethought.  This article, the first of two parts,
    introduces the possibilities and issues of large-scale network design.", 
  location     = "http://www.linux-mag.com/id/1600/"
}

@Article{cidllc,
  author       = "Trevor Harmon",
  title        = "{CORBA} is dead!  {L}ong Live {CORBA}!",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "26--30, 62",
  month        = mar,
  keywords     = "corba, distributed computing, idl, name broker",
  abstract     = "Though it's no longer trendy, CORBA is alive and well in
    Linux.  The rumors of CORBA's demise have been greatly exaggerated.  In
    fact, the Common Object Request Broker Architecture is alive and well, and
    provides valuable services.", 
  location     = "http://www.linux-mag.com/id/1601/"
}

@Article{wdarhlugn,
  author       = "Doug Fort and Joe Griffin",
  title        = "Where Does a {R}ed {H}at {L}inux User Go Now?",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "32--34",
  month        = mar,
  keywords     = "red hat, linux distributions, fedora, system management",
  abstract     = "At the end of April 2004, Red Hat will discontinue its
    support and maintenance of Red Hat Linux, leaving a good number of users in
    a lurch.  While some users will likely switch to SUSE or Debian or others,
    the Fedora Project promises to take up where Red Hat's left off.  But is
    Fedora a viable option? Here's a hands-on trial of Fedora Core 1.", 
  location     = "http://www.linux-mag.com/id/1602/"
}

@Article{ewwjp,
  author       = "Jerry Peek",
  title        = "Even Wilder Wildcards",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "36--38",
  month        = mar,
  keywords     = "shell metacharacters, globbing, zsh",
  abstract     = {In last December’s column, “Wildcards Gone Wild,” we looked
    at ways to match groups of files in a hurry, with a minimum of typing, by
    using shell wildcards .  Last month, we saw some of the wilder things that
    the Z shell, zsh, can do to make computing easier.  This month we’ll mix
    those two topics and look at some of the most powerful zsh wildcards and
    similar, related features in other shells.}, 
  location     = "http://www.jpeek.com/articles/linuxmag/2004-03/"
}

@Article{pwcrws,
  author       = "Roderick~W. Smith",
  title        = "Printing with {CUPS}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "40--42",
  month        = mar,
  keywords     = "cups, printing, network services",
  abstract     = "Printing via Linux has always been a bit tricky, but the
    situation is improving in many ways.  At the forefront of this change is
    the shift from the old Line Printer Daemon (LPD) printing system, as
    implemented in the BSD LPD or LPRng servers, to the newer Common Unix
    Printing System (CUPS).  CUPS is now the default printing system of most
    Linux distributions, as well as with some non-Linux systems, such as Mac OS
    X.", 
  location     = "http://www.linux-mag.com/id/1607/"
}

@Article{wats,
  author       = "Ethan McCallum",
  title        = "Writing a Trace System",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = "50--53",
  month        = mar,
  keywords     = "logging, log server, debugging, syslog",
  abstract     = "Unix is traditionally very text-oriented: configuration files
    are plain ASCII, commands are issued via the shell, tools provide feedback
    via stdout, and daemons and other system services record status in logs.", 
  location     = "http://www.linux-mag.com/id/1609/"
}

@Article{miwt,
  author       = "Jeremy Garcia",
  title        = "Maintaining Integrity with {T}ripwire",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 3,
  pages        = 58,
  month        = mar,
  keywords     = "security, intrusion detection"
}

@Article{sbats,
  author       = "Benjamin Chelf",
  title        = "Squashing Bugs at the Source",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "16--20, 55",
  month        = apr,
  keywords     = "basic blocks, static analysis, debugging",
  abstract     = "Based on new research, source code analysis has been used to
    find thousands of bugs in the Linux 2.6.x kernel.  Here's how the
    technology works, what it can find, and why coding may never be the same
    again.",
  location     = "http://www.linux-mag.com/id/1623/"
}

@Article{zataoaop,
  author       = "Ron Bodkin and Ramnivas Laddad",
  title        = "Zen and the Art of Aspect Oriented Programming",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "22--28",
  month        = apr,
  keywords     = "aspect-oriented programming, object-oriented programming,
    join points, advice, point cuts, refactoring, software development",
  abstract     = "As enterprise systems evolve from concept to code, AN 
    otherwise clean design can become downright, well, messy, as the practical
    plumbing of logging, caching, transactions, and more infiltrates modules.
    Wouldn't it be better if, say, logging were just another module? Enter
    aspect-oriented programming.", 
  location     = "http://www.linux-mag.com/id/1624/"
}

@Article{gzdcry,
  author       = "Dominique Cimafranca and Rex Young",
  title        = "Gnu {Z}ebra",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "30--33, 59",
  month        = apr,
  keywords     = "routing, network management, ospf",
  abstract     = "As your networks grow, you'll want ways to segregate AND
    manage them.  Cisco routers are staples for this purpose, but Linux,
    together with GNU Zebra, can make a good substitute.  Here's how to get up
    and running with Zebra.", 
  location     = "http://www.linux-mag.com/id/1625/"
}

@Article{pvcjp,
  author       = "Jerry Peek",
  title        = "Personal Version Control",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "34--36",
  month        = apr,
  keywords     = "version control, sccs, rcs, cvs, software management",
  abstract     = "If you've worked with a group of programmers, you've
    probably used version control software like CVS.  However, version control
    is also useful for non-programmers -- for instance, for a group of
    technical writers producing product documentation.", 
  location     = "http://www.linux-mag.com/id/1629/"
}

@Article{snsrws,
  author       = "Roderick~W. Smith",
  title        = "{SANE} Network Scanning",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "38--",
  month        = apr,
  keywords     = "scanners, network services",
  abstract     = "Document and image scanners have become an integral part of
    many offices.  With a scanner, you can quickly digitize photos, diagrams,
    and even textual documents for electronic alteration and distribution.", 
  location     = "http://www.linux-mag.com/id/1630/"
}

@Article{capsi,
  author       = "Ethan McCallum",
  title        = "Changing {A} Program's Identity",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "46--49, 61",
  month        = apr,
  keywords     = "setid, unix, security, ids",
  abstract     = "If you've worked with Linux for some time, you've PROBABLY
    used a set-user ID (or setuid) program to temporarily gain permissions
    different from your normal access rights.  Unlike typical programs that run
    with your permissions, a setuid program runs with the permissions of that
    program's owner.  For example, if you launch a program that's setuid and
    owned by root, that program runs as though root had executed it,
    temporarily granting you the same (full) access privileges as the
    superuser.", 
  location     = "http://www.linux-mag.com/id/1632/"
}

@Article{friaf,
  author       = "Jeremy Garcia",
  title        = "Finding Rootkits, Infections, and Files",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "54",
  month        = apr,
  keywords     = "security, find, rootkits",
  abstract     = "Last month's Tech Support showed you how to monitor
    filesystem changes with Tripwire, a handy system utility that alerts you to
    all filesystem changes.  Like SNORT and others, Tripwire's just one of many
    practical security measures that minds your system 24/7.", 
  location     = "http://www.linux-mag.com/id/1635/"
}

@Article{epica,
  author       = "Michael Pelletier",
  title        = "Embedding {P}ython in {C} Applications",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 4,
  pages        = "56--60",
  month        = apr,
  keywords     = "extension languages, scripting languages, embedding
    languages", 
  abstract     = "Many applications, including most of those shipped with
    Windows, Linux, KDE, Gnome, and Apache are written in C.  C is perhaps the
    most universal of all programming languages -- its expressive power,
    portability, minimalism, and speed make it a popular choice.", 
  location     = "http://www.linux-mag.com/id/1633/"
}

@Article{bifef,
  author       = "http://bitconjurer.org/BitTorrent",
  title        = "{BitTorrent}: {ISO}s for Everyone---Fast!",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 2,
  pages        = 10,
  month        = feb,
  keywords     = "peer-to-peer, content distribution, distributed systems",
  abstract     = "Have you ever tried to download the latest ISO images for
    your favorite Linux distribution during the first week that it's available?
    If so, you've probably even had trouble finding an up-to-date mirror that'd
    let you in, and after finding one, you were probably disappointed to see a
    20 KB/sec download speed (or worse) on your cable modem or DSL line that
    normally downloads at 10 times that speed.  And as Linux becomes more
    popular, the problem's only getting worse.", 
  location     = "http://www.linux-mag.com/id/1577/"
}

@Article{stdotsp,
  author       = "Bryan Henderson",
  title        = "{Storage Tank}:  Delivering on the {SAN} Promise",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 2,
  pages        = "28--32",
  month        = feb,
  keywords     = "file systems, sans, caching, lock management, redundancy"
}

@Article{csz,
  author       = "Jerry Peek",
  title        = "Catching Some {ZZZ}s",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 2,
  pages        = "34--36",
  month        = feb,
  keywords     = "globing, shell metacharacters, redirection, process
    substitution, file i-o",
  abstract     = "Linux systems have several shells available -- some more
    powerful than others.  Perhaps the most powerful shell is zsh, the Z shell.
    To give you an idea of the shell's size and complexity, the zshall man page
    in plain-text format weighs in at more than 16,000 lines.", 
  location     = "http://www.linux-mag.com/id/1579/"
}

@Article{mxfrfs,
  author       = "Roderick~F. Smith",
  title        = "Managing {Xft} Fonts",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 2,
  pages        = "38--40",
  month        = feb,
  keywords     = "x, font management, font servers, true-type fonts, type 1
    fonts", 
  abstract     = "Linux's font handling is undergoing a major change.  In the
    past, Linux relied on X's native font-handling systems (known as X core
    fonts), but over time, these systems have become rather ragged.  The
    solution is an entirely different font system, known as Xft.", 
  location     = "http://www.linux-mag.com/id/1580/"
}

@Article{spwr,
  author       = "Ethan McCallum",
  title        = "Software Packaging with {RPM}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 2,
  pages        = "48--51",
  month        = feb,
  keywords     = "software distribution, package management, rpms, red hat",
  abstract     = "If you're running RedHat or a Linux distribution based on 
    RedHat, chances are you've had occasion to use RPMs.  RPMs and Red Hat's
    accompanying package management system (and other systems like it) greatly
    simplify the task of maintaining the software on a system.  With RPMs,
    installs, upgrades, and even downgrades are quick and easy.", 
  location     = "http://www.linux-mag.com/id/1582/"
}

@Article{hhaaig,
  author       = "Jeremy Garcia",
  title        = "Helpful Hints and an {\tt iptables} {GUI}",
  journal      = lmag,
  year         = 2004,
  volume       = 6,
  number       = 2,
  pages        = 58,
  month        = feb,
  keywords     = "pkill, slocate, dos2linux, iptables"
}

@Article{aiafldo,
  author       = "Chandan Kumar Behera and Pawan Kumar",
  title        = "An Improved Algorithm for Loop Dead Optimization",
  journal      = sigplan,
  year         = 2005,
  volume       = 40,
  number       = 11,
  pages        = "18--28",
  month        = nov,
  keywords     = "compiler improvements, code motion",
  abstract     = "Loop dead variables are the variables, which are defined in a
    loop, but not used in that loop.  On successive execution of loop, these
    get different value, however all values (except last value) are not used.
    Hence in optimized program, the definition of a loop dead variable can be
    moved outside the loop (after the loop), rather than computing every time,
    inside the loop.  In our discussion, we have assumed only simple loop.
    Every loop has one entry and one exit point.", 
  location     = "http://dx.doi.org/10.1145/1149982.1149984"
}

@Article{mbcdraiaisqa,
  author       = "Bixin Li and Ying Zhou and Yancheng Wang and Junhui Mo",
  title        = "Matrix-based component dependence representation and its applications in
 software quality assurance ",
  journal      = sigplan,
  year         = 2005,
  volume       = 40,
  number       = 11,
  pages        = "39--36",
  month        = nov,
  keywords     = "dependence analysis, direct dependence graph, dependence
    matrix, software quantity assurance",
  abstract     = "Component dependence analysis is a useful technique that has
    many applications in software engineering activities including software
    understanding, testing, debugging, maintenance, and evolution.  In this
    paper, we propose a matrix-based representation to analyze dependences in
    component-based system (CBSs).  By further investigating the application of
    matrix in analyzing dependences of component-based system, we find that it
    has many applications in software quality assurance.  To make it possible,
    we first identify all types of dependences in a CBS, and then present a
    dependence-based representation called the component dependence graph (CDG)
    and the dependence matrix (DM) to explicitly represent these dependences in
    a CBS.  Based on the CDG and DM, we build a mathematical basis for managing
    and analyzing dependences in a CBS.  Finally, we discuss some important
    applications of the dependence analysis technique in component-based
    software quality assurance, such as understanding, testing, maintenance,
    and evolution etc.", 
  location     = "http://dx.doi.org/10.1145/1107541.1107546"
}

@Article{easlfvbf,
  author       = "Robert~M. Siegfried and Denis Diakoniarakis and
    Kenneth~G. Franqueiro and Amol Jain", 
  title        = "Extending a scripting language for {V}isual {B}asic forms",
  journal      = sigplan,
  year         = 2005,
  volume       = 40,
  number       = 11,
  pages        = "37--40",
  month        = nov,
  keywords     = "visual basic, visual programming, graphical user interfaces,
    blind programmers",
  abstract     = "A prototype scripting language was introduced in 2002 to 
    assist the blind in creating forms for Visual Basic programs in a much
    simpler fashion; currently, creating these forms are particularly difficult
    for the blind and visually impaired.  The language is expanded to include
    the Visual Basic objects that were omitted from the original grammar for
    the scripting language.  A second prototype of the compiler for the
    scripting language is now available online.  An example and a formal
    grammar are included.", 
  location     = "http://dx.doi.org/10.1145/1107541.1107547"
}

@Article{tyofiasnp1,
  author       = "Paul Frenger",
  title        = "Ten years of {F}orth in {ACM} {S}igplan {N}otices: part 1",
  journal      = sigplan,
  year         = 2005,
  volume       = 40,
  number       = 11,
  pages        = "4--16",
  month        = nov,
  keywords     = "forth",
  abstract     = "So here we are: ten years of the ACM Sigplan Notices Forth 
    Report is behind us.  How amazing it is that we have reached this
    milestone! I hope that this column's longevity is a reflection of its
    popularity and perceived value to our readers.", 
  location     = "http://dx.doi.org/10.1145/1107541.1107543"
}

@Article{sdeogds,
  author       = "Christopher~W. Fraser",
  title        = "Syntax-Directed Editing of General Data Structures",
  journal      = sigplan # " (" # pot # "ACM SIGPLAN SIGOA Symposium on Text Manipulation)",
  year         = 1981,
  volume       = 16,
  number       = 6,
  pages        = "17--21",
  month        = jun,
  keywords     = "syntax-directed editors, diagram editors, data structures,
    tree editors",
  abstract     = "Program editors help users create syntactically correct
    programs.  Though such editors normally edit parse trees, applying similar
    techniques to other tree structures that need editing helps both users and
    implementors.  This paper describes an editor that accepts a grammar
    describing a hierarchical data structure and allows the user to enter and
    edit arbitrary trees having this structure.  It displays the pros and cons
    of this approach using instances of this editor that edit formatted
    documents, simple line drawings, and stick figures for trees.", 
  location     = "http://dx.doi.org/10.1145/872730.806449"
}

@Article{asoptpcdt,
  author       = "Stephanos Androutsellis-Theotokis and Diomidis Spinellis",
  title        = "{A} Survey of Peer-to-Peer Content Distribution Technologies",
  journal      = surveys,
  year         = 2004,
  volume       = 36,
  number       = 4,
  pages        = "335--371",
  month        = dec,
  keywords     = "algorithms, design, performance, reliability, security,
    content distribution, distributed hash tables, grid computing,
    peer-to-peer",
  abstract     = "Distributed computer architectures labeled peer-to-peer are 
    designed for the sharing of computer resources (content, storage, CPU
    cycles) by direct exchange, rather than requiring the intermediation or
    support of a centralized server or authority.  Peer-to-peer architectures
    are characterized by their ability to adapt to failures and accommodate
    transient populations of nodes while maintaining acceptable connectivity
    and performance.Content distribution is an important peer-to-peer
    application on the Internet that has received considerable research
    attention.  Content distribution applications typically allow personal
    computers to function in a coordinated manner as a distributed storage
    medium by contributing, searching, and obtaining digital content.In this
    survey, we propose a framework for analyzing peer-to-peer content
    distribution technologies.  Our approach focuses on nonfunctional
    characteristics such as security, scalability, performance, fairness, and
    resource management potential, and examines the way in which these
    characteristics are reflected in---and affected by---the architectural
    design decisions adopted by current peer-to-peer systems.We study current
    peer-to-peer systems and infrastructure technologies in terms of their
    distributed object location and routing mechanisms, their approach to
    content replication, caching and migration, their support for encryption,
    access control, authentication and identity, anonymity, deniability,
    accountability and reputation, and their use of resource trading and
    management schemes.", 
  location     = "http://www.dmst.aueb.gr/dds/pubs/jrnl/2004-ACMCS-p2p/html/AS04.pdf",
  location     = "http://dx.doi.org/10.1145/1041680.1041681"
}

@Article{asotdaaeoalon,
  author       = "Jinu Kurian and Kamil Sarac",
  title        = "{A} Survey on the Design, Applications, and Enhancements of Application-Layer Overlay Networks",
  journal      = surveys,
  year         = 2010,
  volume       = 43,
  number       = 1,
  pages        = "5:0--5:34",
  month        = nov,
  keywords     = "design, economics, performance, reliability, security,
    overlay networks, service overlay networks, performance, enhancements,
    deployment model",
  abstract     = "This article presents a survey of recent advancements in 
    application-layer overlay networks.  Some of the most important
    applications that have been proposed for overlays include multicast, QoS
    support, denial-of-service (DoS) defense, and resilient routing.  We look
    at some of the important approaches proposed for these applications and
    compare the advantages and disadvantages of these approaches.  We also
    examine some of the enhancements that have been proposed in overlay
    topology design, enhanced routing performance, failure resistance, and the
    issues related to coexistence of overlay and native layers in the Internet.
    We conclude the article with a comment on the purist vs pluralist argument
    of overlay networks that has received much debate recently.  Finally, we
    propose a new deployment model for service overlays that seeks to interpose
    between these two approaches.", 
  location     = "http://dx.doi.org/10.1145/1824795.1824800"
}

@Article{tciwahasn,
  author       = "Paolo Santi",
  title        = "Topology Control in Wireless Ad Hoc and Sensor Networks",
  journal      = surveys,
  year         = 2005,
  volume       = 37,
  number       = 2,
  pages        = "164--194",
  month        = jun,
  keywords     = "algorithms, design, connectivity, energy consumption,
    topology control, sensor networks, wireless ad hoc networks, stationary
    networks, energy cost, mobile networks",
  abstract     = "Topology Control (TC) is one of the most important techniques
    used in wireless ad hoc and sensor networks to reduce energy consumption
    (which is essential to extend the network operational time) and radio
    interference (with a positive effect on the network traffic carrying
    capacity).  The goal of this technique is to control the topology of the
    graph representing the communication links between network nodes with the
    purpose of maintaining some global graph property (e.g., connectivity),
    while reducing energy consumption and/or interference that are strictly
    related to the nodes' transmitting range.  In this article, we state
    several problems related to topology control in wireless ad hoc and sensor
    networks, and we survey state-of-the-art solutions which have been proposed
    to tackle them.  We also outline several directions for further research
    which we hope will motivate researchers to undertake additional studies in
    this field.", 
  location     = "http://dx.doi.org/10.1145/1089733.1089736"
}

@Article{asoastcwdiwson,
  author       = "Cigdem Sengul and Aline Carneiro Viana and Artur Ziviani",
  title        = "{A} Survey of Adaptive Services to Cope with Dynamics in Wireless Self-Organizing Networks",
  journal      = surveys,
  year         = 2012,
  volume       = 44,
  number       = 4,
  pages        = "23:0--23:35",
  month        = Aug,
  keywords     = "algorithms, design, adaptive networking services, store and
    forward networks, distributed networks, wireless sensor networks,
    delay-tolerant networks, self-organizing networks, location management,
    resource management, topology management, routing, forwarding, data
    managment, ",
  abstract     = "In this article, we consider different types of wireless
    networks that benefit from and, in certain cases, require
    self-organization.  Taking mobile ad hoc, wireless sensor, wireless mesh,
    and delay-tolerant networks as examples of wireless self-organizing
    networks (WSONs), we identify that the common challenges these networks
    face are mainly due to lack of centralized management, device
    heterogeneity, unreliable wireless communication, mobility, resource
    constraints, or the need to support different traffic types.  In this
    context, we survey several adaptive services proposed to handle these
    challenges.  In particular, we group the adaptive services as core services
    and network-level services.  By categorizing different types of services
    that handle adaptation and the types of adaptations, we intend to provide
    useful design guidelines for achieving self-organizing behavior in network
    protocols.  Finally, we discuss open research problems to encourage the
    design of novel protocols for WSONs.", 
  location     = "http://dx.doi.org/10.1145/2333112.2333118"
}

@Article{asacoptpons,
  author       = "Eng Keong Lua and Jon Crowcroft and Marcelo Pias and Ravi
    Sharma and Steven Lim", 
  title        = "{A} survey and comparison of peer-to-peer overlay network schemes",
  journal      = "IEEE Communications Surveys and Tutorials",
  year         = 2004,
  volume       = 7,
  number       = 2,
  pages        = "72--93",
  month        = mar,
  keywords     = "peer-to-peer, distributed scalable algorithms, lookup
    protocols, overlay routing, overlay networks",
  abstract     = "Over the Internet today, computing and communications
    environments are significantly more complex and chaotic than classical
    distributed systems, lacking any centralized organization or hierarchical
    control.  There has been much interest in emerging Peer-to-Peer (P2P)
    network overlays because they provide a good substrate for creating
    large-scale data sharing, content distribution and application-level
    multicast applications.  These P2P networks try to provide a long list of
    features such as: selection of nearby peers, redundant storage, efficient
    search/location of data items, data permanence or guarantees, hierarchical
    naming, trust and authentication, and, anonymity.  P2P networks potentially
    offer an efficient routing architecture that is self-organizing, massively
    scalable, and robust in the wide-area, combining fault tolerance, load
    balancing and explicit notion of locality.  In this paper, we present a
    survey and comparison of various Structured and Unstructured P2P networks.
    We categorize the various schemes into these two groups in the design
    spectrum and discuss the application-level network performance of each
    group.", 
  location     = "http://www.cl.cam.ac.uk/teaching/2005/AdvSysTop/survey.pdf", 
  location     = "http://dx.doi.org/10.1109/COMST.2005.1610546"
}

@Article{trotb,
  author       = "Tom Pittman",
  title        = "The Return of {T}iny {B}asic",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "24--30",
  month        = jan,
  keywords     = "visual programming languages, grammars, pseudocode,
    interpreters",
  location     = "http://www.drdobbs.com/web-development/the-return-of-tiny-basic/184406381"
}

@Article{told,
  author       = "Guy~L. {Steel, Jr.}",
  title        = "Thoughts on Language Design",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "31--32",
  month        = jan,
  keywords     = "language design, human factors",
  location     = "http://www.drdobbs.com/thoughts-on-language-design/184406382"
}

@Article{rdtrtddd,
  author       = "Truck Smith",
  title        = "Recursive Descent, Tail Recursion, \& the Dreaded Double Divide",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "36--39",
  month        = jan,
  keywords     = "parsing, tail recursion, operator precidence",
  location     = "http://www.drdobbs.com/architecture-and-design/recursive-descent-tail-recursion-the-dr/184406384"
}

@Article{txtrpp,
  author       = "James Britt",
  title        = "Transforming {XML} \& the {REXML} Pull Parser",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "40--45",
  month        = jan,
  keywords     = "dom parsers, xslt, structure transformations, ruby",
  location     = "http://www.drdobbs.com/web-development/transforming-xml-the-rexml-pull-parser/184406385"
}

@Article{ppwpbg,
  author       = "Betsy Gamrat",
  title        = "{PHP} \& Preprocesed Web Pages",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "46--48",
  month        = jan,
  keywords     = "client content, seo",
  abstract     = "Preprocessing lets you deliver complex web pages lightning
    fast, and in a cost-effective manner.",
  location     = "http://www.drdobbs.com/web-development/php-preprocessed-web-pages/184406386"
}

@Article{sijc,
  author       = "David Perelman-Hall",
  title        = "Sorting in {J}ava \& {C}\#",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "49--52",
  month        = jan,
  keywords     = "reflection, sorting",
  abstract     = "David uses reflection to sort a list of complex types using
    both Java and C#.", 
  location     = "http://www.drdobbs.com/jvm/sorting-in-java-c/184406387"
}

@Article{tjla,
  author       = "David Parsons",
  title        = "The {J}ava Location {API}",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "53--58",
  month        = jan,
  keywords     = "location api, proximity listeners, landmarks, j2me,
    references",
  abstract     = "When it comes to real estate and mobile phones, the three
    most important words are location, location, location.", 
  location     = "http://www.drdobbs.com/jvm/the-java-location-api/184406388"
}

@Article{swx,
  author       = "Dionysios~G. Synodinos",
  title        = "Sessioning with {XMLHttpRequest}",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "59--61",
  month        = jan,
  keywords     = "html, javascript, presentation layer, xml data",
  abstract     = "Here's an XMLHttpRequest object that lets you use HTML and
    JavaScript to connect the presentation layer directly to XML data.", 
  location     = "http://www.drdobbs.com/web-development/sessioning-with-xmlhttprequest/184406389"
}

@Article{cmmjrcc,
  author       = "Jose R.~C. Cruz",
  title        = "Cocoa Memory Management",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "62--65",
  month        = jan,
  keywords     = "ui programming, storage management, object management,
    accessors, modifiers, autorelease pool, storage zones",
  abstract     = "Cocoa, a Mac application development framework, has a
    memory-management scheme that differs from Java or C++.",
  location     = "http://www.drdobbs.com/cpp/cocoa-memory-management/184406391"
}

@Article{sicic,
  author       = "Ron Kreymborg",
  title        = "Single Inheritance Classes in {C}",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "68--72",
  month        = jan,
  keywords     = "class structures, vtables, data hiding, inheritance",
  abstract     = "When C++ compilers don't exist for some processors,
    inheritable classes in C may be the best solution.",
  location     = "http://www.drdobbs.com/cpp/single-inheritance-classes-in-c/184406396"
}

@Article{teve,
  author       = "David Orme and Joe Winchester and Gili Mendel",
  title        = "The {E}clipse Visual Editor",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "73--75",
  month        = jan,
  keywords     = "gui builder, extensibility",
  abstract     = "The Eclipse Visual Editor is a subproject that provides a
    framework for creating Eclipse-based GUI builders.",
  location     = "http://www.drdobbs.com/the-eclipse-visual-editor/184406394"
}

@Article{dpd,
  author       = "Tomer Abramson",
  title        = "Detecting Potential Deadlocks",
  journal      = ddj,
  year         = 2006,
  volume       = 31,
  number       = 1,
  pages        = "76--78",
  month        = jan,
  keywords     = "deadlock detection, static analysis",
  abstract     = "To avoid deadlocks, Tomer explains how to use tools that
    detect potential deadlocks each time code is executed.",
  location     = "http://www.drdobbs.com/tools/detecting-potential-deadlocks/184406395"
}

@Manual{masghcnnp,
  title        = "Maintenance and Service Guide: {HP} Compaq nc4400 Notebook {PC}",
  year         = 200,
  month        = may,
  keywords     = "notebook, tablet pc"
}

@Manual{tjfas,
  title        = "Trail: {JAR} Files",
  author       = "Alan Sommerer",
  organization = "Sun Microsystems",
  keywords     = "java, jar, archiving, file management",
  location     = "http://docs.oracle.com/javase/tutorial/deployment/jar/index.html"
}

@Manual{pbeapb,
  title        = "Pharo by Example",
  author       = "Andrew~P. Black and St{\' e}phane Ducasse and Oscar
    Nierstrasz and Damien Pollet",
  organization = "Square Bracket Associates",
  address      = "Switzerland",
  year         = 2009,
  month        = oct,
  keywords     = "pharo, smalltalk, software development",
  location     = "http://pharobyexample.org/"
}

@InProceedings{acapattht,
  author       = "{\" U}lfar Erlingsson and Mark Manasse and Frank McSherry",
  title        = "{A} Cool and Practical Alternative to Traditional Hash Tables",
  booktitle    = pot # "7th Workshop on Distributed Data and Structures",
  year         = 2006,
  pages        = "",
  publisher    = acmp,
  address      = "Santa Clara, " # CA,
  month        = "4--6 " # jan,
  keywords     = "cuckoo hashing",
  abstract     = "Recent advances in the theoretical literature have proposed
    interesting modifications to traditional hash tables.  The authors of 
    these papers propose hash tables which a) have a guaranteed constant time
    for a lookup b) have amortized constant time for an insertion c) require
    table size only slightly larger than the space for the elements Previous
    hash table technologies have offered at most two of these three.  Moreover,
    these hash tables do no dynamic memory allocation (except when the tables
    have to be resized), are easy to code, admit efficient concurrent
    implementations, and can be tuned (even dynamically).  This is enabled by
    one simple idea: allow elements in the hash table to have multiple
    potential locations by using multiple hash functions, and allow elements to
    be relocated among potential locations to make room for new elements.  Such
    relocations can cascade, inducing as earch-tree to find an empty slot, and
    a sequence of relocations to allow the insertion of a new key.",
  location     = ""
}

@inproceedings{sptrsbtrnp,
  author       = "Daniel~R. Edelson",
  title        = "Smart Pointers:  They're Smart, but They're Not Pointers",
  booktitle    = pot # "USENIX C++ Conference",
  year         = 1992,
  pages        = "1--19",
  address      = poor,
  month        = aug,
  keywords     = "raw pointers, inheritance hierarchies, accessors",
  abstract     = "There are numerous times when a C++ user could benefit from
    a pointer variant that has more functionality than is provided by the
    basic, language-defined pointer.  For example, type-accurate garbage
    collection, reference counting, or transparent references to distributed or
    persistent objects, might be implemented with classes that provide pointer
    functionality.  The C++ language directly supports one kind of pointer
    substitute,the smart pointer, in the form of overloadable indirection
    operators: -> and * .  In this paper we evaluate how seamlessly smart
    pointers can replace raw pointers.  The ideal is for client code not to
    care whether it is using raw pointers or smart pointers.  For example, if a
    typedef selects whether raw or smart pointers are used throughout the
    program, changing the value of the typedef should not introduce syntax
    errors.  Unfortunately, C++ does not support pointer substitutes well
    enough to permit seamless integration.  This paper presents the desired
    behavior of smart pointers in terms of the semantics of raw pointers that
    the smart pointers try to emulate.  Then,we describe several ways of
    implementing smart pointers.  For each, we show cases in which the
    smart-pointers fail to behave like raw pointers.  From among the choices,
    we explain which is the best for emulating the standard pointer
    conversions.  Accessors are similar to smart pointers, but have certain
    advantages.  This paper discusses the differences between accessors and
    smart pointers, and shows why our conclusions about type conversion
    behavior also apply to accessors.  Whether a programmer prefers smart
    pointers or accessors, this paper shows the limitations and recommends an
    implementation."
}
 
@InProceedings{pcfgc,
  author       = "Daniel~R. Edelson",
  title        = "Precompiling " # cpp # " for Garbage Collection",
  booktitle    = pot # "International Workshop on Memory Management",
  year         = 1992,
  editor       = "Yves Bekkers and Jaques Cohen",
  pages        = "299--314",
  publisher    = "Springer",
  volume       = 637,
  series       = lncs,
  address      = "St. Malo, France",
  month        = "17--19 " # sep,
  keywords     = "smart pointers, conservative gc",
  abstract     = "Our research is concerned with compiler-independent,
    efficient and convenient garbage collection for C++.  Most collectors
    proposed for C++ have either been implemented in a library or in a
    compiler.  As an intermediate step between those two, this paper proposes
    using precompilation techniques to augment a C++ source program with code
    to allow mostly type-accurate garbage collection.  There are two key
    precompiler transformations.  The first is automatic generation of smart
    pointer classes.  The precompiler defines the smart pointer classes and the
    user utilizes them instead of raw pointers.  These smart pointers supply
    functionality that allows the collector to locate the root set for
    collection.  The second transformation augments the C++ program with code
    that allows the garbage collector to locate internal pointers within
    objects.  This paper describes the precompiler and the garbage collector.
    The paper includes a brief (1500 word) survey of related techniques.", 
  location     = "http://www.soe.ucsc.edu/research/technical-reports/ucsc-crl-92-28/download"
}

@InProceedings{crccpsfen,
  author       = "P. Koopman and T. Chakravarty",
  title        = "Cyclic Redundancy Code ({CRC}) Polynomial Selection For Embedded Networks",
  booktitle    = "International Conference on Dependable Systems and Networks",
  year         = 2004,
  pages        = "145--154",
  address      = "Florence, Italy ",
  month        = "28 " # jun # "- 1 " # jul,
  keywords     = "crc, networking",
  abstract     = "Cyclic redundancy codes (CRCs) provide a first line of 
    defense against data corruption in many networks.  Unfortunately, many
    commonly used CRC polynomials provide significantly less error detection
    capability than they might.  An exhaustive exploration reveals that most
    previously published CRC polynomials are either inferior to alternatives or
    are only good choices for particular message lengths.  Unfortunately these
    shortcomings and limitations often seem to be overlooked.  This paper
    describes a polynomial selection process for embedded network applications
    and proposes a set of good general-purpose polynomials.  A set of 35 new
    polynomials in addition to 13 previously published polynomials provides
    good performance for 3- to 16-bit CRCs for data word lengths up to 2048
    bits.",
  location     = "http://www.ece.cmu.edu/~koopman/crc/index.html"
}

@TechReport{aaviadavoath,
  author       = "Mary Shaw",
  title        = "Abstraction and Verification in {A}lphard:  Design and Verification of a Tree Handler",
  institution  = dcs # cmu,
  year         = 1976,
  address      = ppa,
  month        = jun,
  keywords     = "abstraction, representation, abstract data types, assertions,
    correctness, information hiding, program specifications, program
    verification, programming languages, programming methodology, structured
    programming",
  abstract     = "The design of the Alphard programming language has been
    strongly influenced by ideas from the areas of programming methodology and
    formal program verification.  The interaction of these ideas and their
    influence on Alphard are described by developing a nontrivial example, a
    program for manipulating the parse tree of an arithmetic expression.", 
  location     = ""
}

@TechReport{paesfma,
  author       = "Andy Hopper",
  title        = "Pandora --- An Experimental System for Multimedia Applications",
  institution  = "Olivetti Research",
  year         = 1990,
  number       = "90--1",
  OPTaddress   = "Cambridge, UK",
  keywords     = "multi-media workstations, video, compression, networking, ",
  abstract     = "Pandora is a joint project between Olivetti Research
    Cambridge and the University of Cambridge Computer Laboratory.  The project
    is investigating the use of multimedia workstations in a working
    environment with particular emphasis on digital video.  It endeavours to
    place a camera on the desktop to make generation of multimedia documents as
    easy as producing text.  We are aiming to produce a number of new
    applications as well as to provide insights into the way computer systems
    should be designed.The project is in three stages.  In the first a
    peripheral, Pandora's Box, has been designed.  This box can be attached to
    any one of a range of workstations and provides multimedia features.  In
    the second stage a number of such systems are being deployed amongst a
    community of systems developers and application writers.  Finally we will
    use the experimental system in our daily work to evaluate new applications.
    From the users point of view the normal workstation environment is
    maintained but additional features are available.This paper describes the
    design decisions which must be taken when incorporating video in a
    workstation.  A description of the Pandora's Box peripheral which provides
    multimedia features is given.  Finally the distributed system under
    construction is discussed.", 
  location     = "http://www.cl.cam.ac.uk/research/dtg/attarchive/pub/docs/att/tr.90.1.pdf"
}

@TechReport{cic,
  author       = "R. Braden and D. Borman and Craig Partridge",
  title        = "Computing the {I}nternet Checksums",
  institution  = ietf,
  year         = 1988,
  type         = "RFC",
  number       = "1071",
  month        = sep,
  keywords     = "checksums, performance, optimizations, coding",
  abstract     = "This memo summarizes techniques and algorithms for 
    efficiently computing the Internet checksum.  It is not a standard, but a
    set of useful implementation techniques.  Distribution of this memo is
    unlimited.",
  location     = "http://www.ietf.org/rfc/rfc1071.txt"
}

@TechReport{tpal,
  author       = "Leslie Lamport",
  title        = "The {PlusCal} Algorithm Language",
  institution  = "Microsoft Research",
  year         = 2009,
  month        = jan,
  keywords     = "tla+, model checking, algorithm description language",
  abstract     = "Algorithms are different from programs and should not be 
    described with programming languages.  The only simple alternative to
    programming languages has been pseudo-code.  PlusCal is an algorithm
    language that can be used right now to replace pseudo-code, for both
    sequential and concurrent algorithms.  It is based on the TLA+
    specification language, and a PlusCal algorithm is automatically translated
    to a TLA+ specification that can be checked with the TLC model checker and
    reasoned about formally.", 
  location     = "http://research.microsoft.com/en-us/um/people/lamport/pubs/pluscal.pdf"
}

@TechReport{anstftmorsidi,
  author       = "Guido Hogen and Rita Loogen",
  title        = "{A} New Stack Technique for the Management of Runtime Structures in Distribued Implementations",
  institution  = "Lehstuhl f{\" u}r Informatik, RWTH Aachen",
  year         = 1993,
  number       = "93--3",
  address      = "Aachen, Germany",
  keywords     = "functional languages, reduction semantics, meshed stacks,
    parallelism, process management, message handling",
  abstract     = "A new technique for the management of runtime structures in 
    distributed implementations is presented.  Instead of storing the runtime
    stacks of parallel processes as linked lists of function blocks in a heap
    structure, the local stacks of several parallel processes, which are
    executed on the same processor element, are stored in an interleaved manner
    on a single physical stack, called the meshed stack.  The technique
    originated from the stack organisation in the well known Warren Abstract
    Machine (WAM) for logic languages, where the runtime information of several
    alternative computation branches is stored on a single stack." 
}

@TechReport{armtna,
  author       = "Thomas Narten",
  title        = "{A} Road Map Through {N}achos",
  institution  = dcs # "Duke University",
  year         = 1995,
  address      = "Durham, N.C.",
  month        = 4 # " " # jan,
  keywords     = "threads, user-level processes, file systems, operating
    systems, simulators",
  abstract     = "Nachos is instructional software that allows students to 
    examine, modify and execute operating system software.  Nachos provides a
    skeletal operating system that supports threads, user-level processes,
    virtual memory and interrupt-driven input output devices.  Nachos is a
    complex piece of software and it is difficult for beginning students (and
    instructors) to easily gain on overall understanding of the various system
    pieces and how they fit together.  This document provides a road map to
    understanding the Nachos system.  It gives a high-level overview of the
    source code, focusing on the big picture rather than on the details.  It is
    not intended as a replacement for reading the source code.  Rather, it is a
    companion that is intended to help students (and instructors) overcome the
    initial learning curve encountered when learning and using the system.", 
  location     = "http://www.cs.duke.edu/~narten/110/nachos/main.ps"
}

@PhDThesis{aaeitiopl,
  author       = "Michael Lee Horowitz",
  title        = "Automatically Achieving Elasticity in the Implementation of Programming Languages",
  school       = dcs # cmu,
  year         = 1988,
  address      = ppa,
  month        = jan,
  keywords     = "language design, binding time, event-driven compilation,
    elasticity",
  abstract     = "Several developments in programming language design and 
    software engineering lead to a reexamination of the role of binding times
    in programming language implementation.  We can alleviate problems
    associated with these developments by using event-driven processing to
    determine translation binding times.  Our ultimate goal is to clarify the
    effects of different designs on binding times and to reduce binding time
    concerns in the language design process.  Determining the binding time of a
    translation action involves two concerns: the ordering of the action's
    execution relative to other actions and the translation phase in which the
    execution occurs (e.g.  compile time, link-time, or run-time).  Some issues
    that affect these concerns include: how to handle forward references,
    language designs that require dynamic interpretation, the role of link-time
    in languages that allow separate compilation, and how to achieve
    elasticity.  Elasticity occurs when similar translation actions may be
    executed at very different binding times, typically in different
    translation phases.  In particular, the binding time of each translation
    action is determined individually.  Elastic translation, therefore, incurs
    the costs of late bindings only when language flexibility is used by the
    programmer.  Otherwise, the programmer receives the benefits associated
    with static binding times (e.g.  early error notification and efficient
    program execution).  We can model language translation as an event-driven
    process.  Each semantic action needed to translate a program may be viewed
    as an event.  Each event becomes enabled when its required data becomes
    available.  Event-driven translation progresses by executing those events
    initially enabled and continuing with those enabled as a result.  Since
    each action is handled individually, event-driven translation naturally
    determines the proper ordering and phase for executing events and achieves
    elasticity.  We can also generate event-driven translation systems
    automatically.  Automatic generation removes from the language implementor
    the need to understand the event-driven translation model.  In particular,
    event-driven systems can be generated from a known specification formalism
    (i.e.  attribute grammars).  An automatic generator of event-driven
    translators can also provide useful information about binding times during
    the language design process.  Finally, event-driven systems may have
    potential in practical language implementations.  This thesis describes
    translation problems, the event-driven translation model, a generator of
    event-driven translators, a language design based on elasticity, and an
    evaluation of the model for practical language translation.  Elastic
    translation has particular promise in the design and implementation of
    programming environments and command languages.  Event-driven translation
    may also provide the means to quantify well-known design principles such as
    avoiding pre-emptive decisions.", 
  location     = "http://reports-archive.adm.cs.cmu.edu/anon/scan/CMU-CS-88-120.pdf"
}

@InBook{as13ksblk,
  author       = "Kenneth Solnneger and Barry~L. Kurtz",
  title        = "Formal Syntax and Semantics of Programming Languages",
  chapter      = "13: Action Semantics",
  publisher    = aw,
  year         = 1995,
  pages        = "507--564",
  address      = rma,
  keywords     = "action semantics",
  location     = "QA 76.7.S59"
}

